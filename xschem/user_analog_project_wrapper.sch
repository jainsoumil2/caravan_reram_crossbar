C {devices/lab_wire.sym} 3790 -12960 0 0 {name=l4251 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -12980 0 0 {name=l4252 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -13020 0 0 {name=l4253 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -13000 0 0 {name=l4254 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -13040 0 0 {name=l4255 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -13060 0 0 {name=l4256 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -13080 0 0 {name=l4257 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -13100 0 0 {name=l4258 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -12800 0 0 {name=l4259 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -12820 0 1 {name=l4260 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -12840 0 1 {name=l4261 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -12860 0 1 {name=l4262 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -12880 0 1 {name=l4263 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -12900 0 1 {name=l4264 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -12920 0 1 {name=l4265 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -12940 0 1 {name=l4266 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -12960 0 1 {name=l4267 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -12980 0 1 {name=l4268 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -13020 0 1 {name=l4269 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -13000 0 1 {name=l4270 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -13040 0 1 {name=l4271 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -13060 0 1 {name=l4272 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -13080 0 1 {name=l4273 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -13100 0 1 {name=l4274 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -12800 0 1 {name=l4275 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -13970 2 1 {name=l4276 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -13990 0 0 {name=l4277 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -14090 0 0 {name=l4278 lab=row6_sel}
C {devices/lab_pin.sym} 2340 -14070 0 0 {name=l4279 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -14010 0 0 {name=l4280 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -14050 0 0 {name=l4281 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -14030 0 0 {name=l4282 lab=WR}
C {devices/lab_pin.sym} 2340 -13950 2 1 {name=l4283 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -13890 0 0 {name=l4284 lab=Vref}
C {devices/lab_pin.sym} 2340 -13850 0 0 {name=l4285 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -13870 0 0 {name=l4286 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -13910 2 1 {name=l4287 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -13930 2 1 {name=l4288 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -13960 2 1 {name=l4289 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -13980 0 0 {name=l4290 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -14080 0 0 {name=l4291 lab=row6_sel}
C {devices/lab_pin.sym} 3040 -14060 0 0 {name=l4292 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -14000 0 0 {name=l4293 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -14040 0 0 {name=l4294 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -14020 0 0 {name=l4295 lab=WR}
C {devices/lab_pin.sym} 3040 -13940 2 1 {name=l4296 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -13880 0 0 {name=l4297 lab=Vref}
C {devices/lab_pin.sym} 3040 -13840 0 0 {name=l4298 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -13860 0 0 {name=l4299 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -13900 2 1 {name=l4300 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -13920 2 1 {name=l4301 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -13960 2 1 {name=l4302 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -13980 0 0 {name=l4303 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -14080 0 0 {name=l4304 lab=row6_sel}
C {devices/lab_pin.sym} 3750 -14060 0 0 {name=l4305 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -14000 0 0 {name=l4306 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -14040 0 0 {name=l4307 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -14020 0 0 {name=l4308 lab=WR}
C {devices/lab_pin.sym} 3750 -13940 2 1 {name=l4309 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -13880 0 0 {name=l4310 lab=Vref}
C {devices/lab_pin.sym} 3750 -13840 0 0 {name=l4311 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -13860 0 0 {name=l4312 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -13900 2 1 {name=l4313 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -13920 2 1 {name=l4314 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -13970 2 1 {name=l4315 lab=Vrminus}
C {devices/lab_pin.sym} 190 -13990 0 0 {name=l4316 lab=SAMPLE}
C {devices/lab_pin.sym} 190 -14010 0 0 {name=l4317 lab=Vgpr}
C {devices/lab_pin.sym} 190 -14050 0 0 {name=l4318 lab=Vgnr}
C {devices/lab_pin.sym} 190 -14030 0 0 {name=l4319 lab=WR}
C {devices/lab_pin.sym} 190 -13950 2 1 {name=l4320 lab=Vrplus}
C {devices/lab_pin.sym} 190 -13890 0 0 {name=l4321 lab=Vref}
C {devices/lab_pin.sym} 190 -13850 0 0 {name=l4322 lab=Vcplus}
C {devices/lab_pin.sym} 190 -13870 0 0 {name=l4323 lab=Vcminus}
C {devices/lab_pin.sym} 190 -13910 2 1 {name=l4324 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 190 -13930 2 1 {name=l4325 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 610 -14050 2 0 {name=l4326 lab=vdda1}
C {devices/lab_pin.sym} 610 -14070 2 0 {name=l4328 lab=vccd1}
C {devices/lab_pin.sym} 610 -14090 2 0 {name=l4329 lab=latch_high0}
C {devices/lab_pin.sym} 2030 -14080 2 0 {name=l4330 lab=latch_high2}
C {devices/lab_pin.sym} 2760 -14090 2 0 {name=l4331 lab=latch_high3}
C {devices/lab_pin.sym} 3460 -14080 2 0 {name=l4332 lab=latch_high4}
C {devices/lab_pin.sym} 4170 -14080 2 0 {name=l4333 lab=latch_high5}
C {devices/lab_pin.sym} 1330 -14090 2 0 {name=l4334 lab=latch_high1}
C {devices/lab_pin.sym} -760 -1320 2 1 {name=l4335 lab=EN}
C {devices/lab_pin.sym} 610 -1770 2 0 {name=l4133 lab=vdda1}
C {devices/lab_pin.sym} 610 -1750 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 610 -1790 2 0 {name=l4135 lab=vccd1}
C {devices/lab_pin.sym} 1330 -1750 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 2030 -1740 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 2760 -1750 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 3460 -1740 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 4170 -1740 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 610 -3880 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 1330 -3880 0 1 {name=l1 lab=vssa1}
C {devices/lab_pin.sym} 2030 -3870 0 1 {name=l2 lab=vssa1}
C {devices/lab_pin.sym} 2760 -3880 0 1 {name=l3 lab=vssa1}
C {devices/lab_pin.sym} 3460 -3870 0 1 {name=l4 lab=vssa1}
C {devices/lab_pin.sym} 4170 -3870 0 1 {name=l5 lab=vssa1}
C {devices/lab_pin.sym} 610 -5880 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 1330 -5880 0 1 {name=l1 lab=vssa1}
C {devices/lab_pin.sym} 2030 -5870 0 1 {name=l2 lab=vssa1}
C {devices/lab_pin.sym} 2760 -5880 0 1 {name=l3 lab=vssa1}
C {devices/lab_pin.sym} 3460 -5870 0 1 {name=l4 lab=vssa1}
C {devices/lab_pin.sym} 4170 -5870 0 1 {name=l5 lab=vssa1}
C {devices/lab_pin.sym} 610 -7900 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 1330 -7900 0 1 {name=l1 lab=vssa1}
C {devices/lab_pin.sym} 2030 -7890 0 1 {name=l2 lab=vssa1}
C {devices/lab_pin.sym} 2760 -7900 0 1 {name=l3 lab=vssa1}
C {devices/lab_pin.sym} 3460 -7890 0 1 {name=l4 lab=vssa1}
C {devices/lab_pin.sym} 4170 -7890 0 1 {name=l5 lab=vssa1}
C {devices/lab_pin.sym} 610 -9890 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 1330 -9890 0 1 {name=l1 lab=vssa1}
C {devices/lab_pin.sym} 2030 -9880 0 1 {name=l2 lab=vssa1}
C {devices/lab_pin.sym} 2760 -9890 0 1 {name=l3 lab=vssa1}
C {devices/lab_pin.sym} 3460 -9880 0 1 {name=l4 lab=vssa1}
C {devices/lab_pin.sym} 4170 -9880 0 1 {name=l5 lab=vssa1}
C {devices/lab_pin.sym} 610 -11960 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 1330 -11960 0 1 {name=l1 lab=vssa1}
C {devices/lab_pin.sym} 2030 -11950 0 1 {name=l2 lab=vssa1}
C {devices/lab_pin.sym} 2760 -11960 0 1 {name=l3 lab=vssa1}
C {devices/lab_pin.sym} 3460 -11950 0 1 {name=l4 lab=vssa1}
C {devices/lab_pin.sym} 4170 -11950 0 1 {name=l5 lab=vssa1}
C {devices/lab_pin.sym} 610 -14030 0 1 {name=l4134 lab=vssa1}
C {devices/lab_pin.sym} 1330 -14030 0 1 {name=l1 lab=vssa1}
C {devices/lab_pin.sym} 2030 -14020 0 1 {name=l2 lab=vssa1}
C {devices/lab_pin.sym} 2760 -14030 0 1 {name=l3 lab=vssa1}
C {devices/lab_pin.sym} 3460 -14020 0 1 {name=l4 lab=vssa1}
C {devices/lab_pin.sym} 4170 -14020 0 1 {name=l5 lab=vssa1}
