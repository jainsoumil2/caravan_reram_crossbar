C {devices/bus_connect_nolab.sym} 3040 -2670 2 0 {name=r1352}
C {devices/bus_connect_nolab.sym} 3040 -2690 2 0 {name=r1353}
C {devices/bus_connect_nolab.sym} 3040 -2710 2 0 {name=r1354}
C {devices/bus_connect_nolab.sym} 3040 -2730 2 0 {name=r1355}
C {devices/bus_connect_nolab.sym} 3040 -2750 2 0 {name=r1356}
C {devices/bus_connect_nolab.sym} 3040 -2770 2 0 {name=r1357}
C {devices/bus_connect_nolab.sym} 3040 -2790 2 0 {name=r1358}
C {devices/bus_connect_nolab.sym} 3040 -2810 2 0 {name=r1359}
C {devices/bus_connect_nolab.sym} 3040 -2830 2 0 {name=r1360}
C {devices/bus_connect_nolab.sym} 3040 -2850 2 0 {name=r1361}
C {devices/bus_connect_nolab.sym} 3040 -2870 2 0 {name=r1362}
C {devices/bus_connect_nolab.sym} 3040 -2890 2 0 {name=r1363}
C {devices/bus_connect_nolab.sym} 3040 -2910 2 0 {name=r1364}
C {devices/bus_connect_nolab.sym} 3040 -2930 2 0 {name=r1365}
C {devices/bus_connect_nolab.sym} 3040 -2950 2 0 {name=r1366}
C {devices/lab_pin.sym} 3030 -2610 3 0 {name=l921 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -2650 2 1 {name=r1367}
C {devices/bus_connect_nolab.sym} 3460 -2670 2 1 {name=r1368}
C {devices/bus_connect_nolab.sym} 3460 -2690 2 1 {name=r1369}
C {devices/bus_connect_nolab.sym} 3460 -2710 2 1 {name=r1370}
C {devices/bus_connect_nolab.sym} 3460 -2730 2 1 {name=r1371}
C {devices/bus_connect_nolab.sym} 3460 -2750 2 1 {name=r1372}
C {devices/bus_connect_nolab.sym} 3460 -2770 2 1 {name=r1373}
C {devices/bus_connect_nolab.sym} 3460 -2790 2 1 {name=r1374}
C {devices/bus_connect_nolab.sym} 3460 -2810 2 1 {name=r1375}
C {devices/bus_connect_nolab.sym} 3460 -2830 2 1 {name=r1376}
C {devices/bus_connect_nolab.sym} 3460 -2850 2 1 {name=r1377}
C {devices/bus_connect_nolab.sym} 3460 -2870 2 1 {name=r1378}
C {devices/bus_connect_nolab.sym} 3460 -2890 2 1 {name=r1379}
C {devices/bus_connect_nolab.sym} 3460 -2910 2 1 {name=r1380}
C {devices/bus_connect_nolab.sym} 3460 -2930 2 1 {name=r1381}
C {devices/bus_connect_nolab.sym} 3460 -2950 2 1 {name=r1382}
C {devices/lab_pin.sym} 3470 -2610 1 1 {name=l922 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -2670 0 0 {name=l923 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -2690 0 0 {name=l924 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -2710 0 0 {name=l925 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -2730 0 0 {name=l926 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -2750 0 0 {name=l927 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -2770 0 0 {name=l928 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -2790 0 0 {name=l929 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -2810 0 0 {name=l930 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -2830 0 0 {name=l931 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -2870 0 0 {name=l932 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -2850 0 0 {name=l933 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -2890 0 0 {name=l934 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -2910 0 0 {name=l935 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -2930 0 0 {name=l936 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -2950 0 0 {name=l937 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -2650 0 0 {name=l938 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -2670 0 1 {name=l939 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -2690 0 1 {name=l940 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -2710 0 1 {name=l941 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -2730 0 1 {name=l942 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -2750 0 1 {name=l943 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -2770 0 1 {name=l944 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -2790 0 1 {name=l945 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -2810 0 1 {name=l946 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -2830 0 1 {name=l947 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -2870 0 1 {name=l948 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -2850 0 1 {name=l949 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -2890 0 1 {name=l950 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -2910 0 1 {name=l951 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -2930 0 1 {name=l952 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -2950 0 1 {name=l953 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -2650 0 1 {name=l954 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -3330 2 0 {name=r1383}
C {devices/bus_connect_nolab.sym} 3600 -3350 2 0 {name=r1384}
C {devices/bus_connect_nolab.sym} 3600 -3370 2 0 {name=r1385}
C {devices/bus_connect_nolab.sym} 3600 -3390 2 0 {name=r1386}
C {devices/bus_connect_nolab.sym} 3600 -3410 2 0 {name=r1387}
C {devices/bus_connect_nolab.sym} 3600 -3430 2 0 {name=r1388}
C {devices/bus_connect_nolab.sym} 3600 -3450 2 0 {name=r1389}
C {devices/bus_connect_nolab.sym} 3600 -3470 2 0 {name=r1390}
C {devices/bus_connect_nolab.sym} 3600 -3490 2 0 {name=r1391}
C {devices/bus_connect_nolab.sym} 3600 -3510 2 0 {name=r1392}
C {devices/bus_connect_nolab.sym} 3600 -3550 2 0 {name=r1393}
C {devices/bus_connect_nolab.sym} 3600 -3530 2 0 {name=r1394}
C {devices/bus_connect_nolab.sym} 3600 -3590 2 0 {name=r1395}
C {devices/bus_connect_nolab.sym} 3600 -3570 2 0 {name=r1396}
C {devices/bus_connect_nolab.sym} 3600 -3630 2 0 {name=r1397}
C {devices/bus_connect_nolab.sym} 3600 -3610 2 0 {name=r1398}
C {devices/lab_wire.sym} 3650 -3330 0 0 {name=l955 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -3350 0 0 {name=l956 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -3370 0 0 {name=l957 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -3370 0 0 {name=l958 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -3390 0 0 {name=l959 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -3410 0 0 {name=l960 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -3430 0 0 {name=l961 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -3450 0 0 {name=l962 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -3470 0 0 {name=l963 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -3490 0 0 {name=l964 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -3510 0 0 {name=l970 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -3550 0 0 {name=l971 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -3530 0 0 {name=l972 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -3570 0 0 {name=l973 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -3590 0 0 {name=l974 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -3610 0 0 {name=l975 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -3630 0 0 {name=l976 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -3280 3 0 {name=l977 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -3330 2 1 {name=r1399}
C {devices/bus_connect_nolab.sym} 4220 -3350 2 1 {name=r1400}
C {devices/bus_connect_nolab.sym} 4220 -3370 2 1 {name=r1401}
C {devices/bus_connect_nolab.sym} 4220 -3390 2 1 {name=r1402}
C {devices/bus_connect_nolab.sym} 4220 -3410 2 1 {name=r1403}
C {devices/bus_connect_nolab.sym} 4220 -3430 2 1 {name=r1404}
C {devices/bus_connect_nolab.sym} 4220 -3450 2 1 {name=r1405}
C {devices/bus_connect_nolab.sym} 4220 -3470 2 1 {name=r1406}
C {devices/bus_connect_nolab.sym} 4220 -3490 2 1 {name=r1407}
C {devices/bus_connect_nolab.sym} 4220 -3510 2 1 {name=r1408}
C {devices/bus_connect_nolab.sym} 4220 -3530 2 1 {name=r1409}
C {devices/bus_connect_nolab.sym} 4220 -3550 2 1 {name=r1410}
C {devices/bus_connect_nolab.sym} 4220 -3570 2 1 {name=r1411}
C {devices/bus_connect_nolab.sym} 4220 -3590 2 1 {name=r1412}
C {devices/bus_connect_nolab.sym} 4220 -3610 2 1 {name=r1413}
C {devices/bus_connect_nolab.sym} 4220 -3630 2 1 {name=r1414}
C {devices/lab_pin.sym} 4230 -3280 3 0 {name=l978 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -3630 0 1 {name=l979 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -3610 0 1 {name=l980 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -3590 0 1 {name=l981 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -3570 0 1 {name=l982 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -3550 0 1 {name=l983 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -3530 0 1 {name=l984 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -3510 0 1 {name=l985 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -3490 0 1 {name=l986 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -3470 0 1 {name=l987 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -3450 0 1 {name=l988 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -3430 0 1 {name=l989 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -3410 0 1 {name=l990 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -3390 0 1 {name=l991 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -3370 0 1 {name=l992 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -3350 0 1 {name=l993 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -3330 0 1 {name=l994 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -2650 2 0 {name=r1415}
C {devices/bus_connect_nolab.sym} 3750 -2670 2 0 {name=r1416}
C {devices/bus_connect_nolab.sym} 3750 -2690 2 0 {name=r1417}
C {devices/bus_connect_nolab.sym} 3750 -2710 2 0 {name=r1418}
C {devices/bus_connect_nolab.sym} 3750 -2730 2 0 {name=r1419}
C {devices/bus_connect_nolab.sym} 3750 -2750 2 0 {name=r1420}
C {devices/bus_connect_nolab.sym} 3750 -2770 2 0 {name=r1421}
C {devices/bus_connect_nolab.sym} 3750 -2790 2 0 {name=r1422}
C {devices/bus_connect_nolab.sym} 3750 -2810 2 0 {name=r1423}
C {devices/bus_connect_nolab.sym} 3750 -2830 2 0 {name=r1424}
C {devices/bus_connect_nolab.sym} 3750 -2850 2 0 {name=r1425}
C {devices/bus_connect_nolab.sym} 3750 -2870 2 0 {name=r1426}
C {devices/bus_connect_nolab.sym} 3750 -2890 2 0 {name=r1427}
C {devices/bus_connect_nolab.sym} 3750 -2910 2 0 {name=r1428}
C {devices/bus_connect_nolab.sym} 3750 -2930 2 0 {name=r1429}
C {devices/bus_connect_nolab.sym} 3750 -2950 2 0 {name=r1430}
C {devices/lab_pin.sym} 3740 -2610 3 0 {name=l995 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -2650 2 1 {name=r1431}
C {devices/bus_connect_nolab.sym} 4170 -2670 2 1 {name=r1432}
C {devices/bus_connect_nolab.sym} 4170 -2690 2 1 {name=r1433}
C {devices/bus_connect_nolab.sym} 4170 -2710 2 1 {name=r1434}
C {devices/bus_connect_nolab.sym} 4170 -2730 2 1 {name=r1435}
C {devices/bus_connect_nolab.sym} 4170 -2750 2 1 {name=r1436}
C {devices/bus_connect_nolab.sym} 4170 -2770 2 1 {name=r1437}
C {devices/bus_connect_nolab.sym} 4170 -2790 2 1 {name=r1438}
C {devices/bus_connect_nolab.sym} 4170 -2810 2 1 {name=r1439}
C {devices/bus_connect_nolab.sym} 4170 -2830 2 1 {name=r1440}
C {devices/bus_connect_nolab.sym} 4170 -2850 2 1 {name=r1441}
C {devices/bus_connect_nolab.sym} 4170 -2870 2 1 {name=r1442}
C {devices/bus_connect_nolab.sym} 4170 -2890 2 1 {name=r1443}
C {devices/bus_connect_nolab.sym} 4170 -2910 2 1 {name=r1444}
C {devices/bus_connect_nolab.sym} 4170 -2930 2 1 {name=r1445}
C {devices/bus_connect_nolab.sym} 4170 -2950 2 1 {name=r1446}
C {devices/lab_pin.sym} 4180 -2610 1 1 {name=l996 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -2670 0 0 {name=l997 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -2690 0 0 {name=l998 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -2710 0 0 {name=l999 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -2730 0 0 {name=l1000 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -2750 0 0 {name=l1001 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -2770 0 0 {name=l1002 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -2790 0 0 {name=l1003 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3790 -2810 0 0 {name=l1004 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -2830 0 0 {name=l1005 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -2870 0 0 {name=l1006 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -2850 0 0 {name=l1007 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -2890 0 0 {name=l1008 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -2910 0 0 {name=l1009 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -2930 0 0 {name=l1010 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -2950 0 0 {name=l1011 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -2650 0 0 {name=l1012 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -2670 0 1 {name=l1013 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -2690 0 1 {name=l1014 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -2710 0 1 {name=l1015 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -2730 0 1 {name=l1016 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -2750 0 1 {name=l1017 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -2770 0 1 {name=l1018 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -2790 0 1 {name=l1019 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -2810 0 1 {name=l1020 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -2830 0 1 {name=l1021 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -2870 0 1 {name=l1022 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -2850 0 1 {name=l1023 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -2890 0 1 {name=l1024 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -2910 0 1 {name=l1025 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -2930 0 1 {name=l1026 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -2950 0 1 {name=l1027 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -2650 0 1 {name=l1028 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -3820 2 1 {name=l1029 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -3840 0 0 {name=l1030 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -3940 0 0 {name=l1031 lab=row1_sel}
C {devices/lab_pin.sym} 2340 -3920 0 0 {name=l1032 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -3860 0 0 {name=l1033 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -3900 0 0 {name=l1034 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -3880 0 0 {name=l1035 lab=WR}
C {devices/lab_pin.sym} 2340 -3800 2 1 {name=l1036 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -3740 0 0 {name=l1037 lab=Vref}
C {devices/lab_pin.sym} 2340 -3700 0 0 {name=l1038 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -3720 0 0 {name=l1039 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -3760 2 1 {name=l1040 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -3780 2 1 {name=l1041 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -3810 2 1 {name=l1042 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -3830 0 0 {name=l1043 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -3930 0 0 {name=l1044 lab=row1_sel}
C {devices/lab_pin.sym} 3040 -3910 0 0 {name=l1045 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -3850 0 0 {name=l1046 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -3890 0 0 {name=l1047 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -3870 0 0 {name=l1048 lab=WR}
C {devices/lab_pin.sym} 3040 -3790 2 1 {name=l1049 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -3730 0 0 {name=l1050 lab=Vref}
C {devices/lab_pin.sym} 3040 -3690 0 0 {name=l1051 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -3710 0 0 {name=l1052 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -3750 2 1 {name=l1053 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -3770 2 1 {name=l1054 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -3810 2 1 {name=l1055 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -3830 0 0 {name=l1056 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -3930 0 0 {name=l3989 lab=row1_sel}
C {devices/lab_pin.sym} 3750 -3910 0 0 {name=l4155 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -3850 0 0 {name=l4156 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -3890 0 0 {name=l4157 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -3870 0 0 {name=l4158 lab=WR}
C {devices/lab_pin.sym} 3750 -3790 2 1 {name=l4159 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -3730 0 0 {name=l4160 lab=Vref}
C {devices/lab_pin.sym} 3750 -3690 0 0 {name=l4161 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -3710 0 0 {name=l4162 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -3750 2 1 {name=l4163 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -3770 2 1 {name=l4164 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -5940 0 0 {name=l1057 lab=row2_sel}
C {devices/lab_pin.sym} 190 -5920 0 0 {name=l1058 lab=col0_sel}
C {devices/lab_pin.sym} 910 -5820 2 1 {name=l1059 lab=Vrminus}
C {devices/lab_pin.sym} 910 -5840 0 0 {name=l1060 lab=SAMPLE}
C {devices/lab_pin.sym} 2760 -5900 2 0 {name=l1061 lab=vdda1}
C {devices/lab_pin.sym} 2760 -5920 2 0 {name=l1063 lab=vccd1}
C {devices/lab_pin.sym} 3460 -5890 2 0 {name=l1064 lab=vdda1}
C {devices/lab_pin.sym} 3460 -5910 2 0 {name=l1066 lab=vccd1}
C {devices/lab_pin.sym} 4170 -5890 2 0 {name=l1067 lab=vdda1}
C {devices/lab_pin.sym} 4170 -5910 2 0 {name=l1069 lab=vccd1}
C {devices/lab_wire.sym} 130 -5300 0 0 {name=l1070 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -5280 0 0 {name=l1071 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -5260 0 0 {name=l1072 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -5240 0 0 {name=l1073 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -5220 0 0 {name=l1074 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -5200 0 0 {name=l1075 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -5180 0 0 {name=l1076 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -5160 0 0 {name=l1077 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -5140 0 0 {name=l1078 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -5120 0 0 {name=l1079 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -5100 0 0 {name=l1080 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -5080 0 0 {name=l1081 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -5060 0 0 {name=l1082 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -5040 0 0 {name=l1083 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -5020 0 0 {name=l1084 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -5000 0 0 {name=l1085 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -4960 3 0 {name=l1086 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -5000 2 0 {name=r199}
C {devices/bus_connect_nolab.sym} 70 -5020 2 0 {name=r200}
C {devices/bus_connect_nolab.sym} 70 -5040 2 0 {name=r201}
C {devices/bus_connect_nolab.sym} 70 -5060 2 0 {name=r202}
C {devices/bus_connect_nolab.sym} 70 -5080 2 0 {name=r203}
C {devices/bus_connect_nolab.sym} 70 -5100 2 0 {name=r204}
C {devices/bus_connect_nolab.sym} 70 -5120 2 0 {name=r205}
C {devices/bus_connect_nolab.sym} 70 -5140 2 0 {name=r206}
C {devices/bus_connect_nolab.sym} 70 -5160 2 0 {name=r207}
C {devices/bus_connect_nolab.sym} 70 -5180 2 0 {name=r208}
C {devices/bus_connect_nolab.sym} 70 -5200 2 0 {name=r209}
C {devices/bus_connect_nolab.sym} 70 -5220 2 0 {name=r210}
C {devices/bus_connect_nolab.sym} 70 -5240 2 0 {name=r211}
C {devices/bus_connect_nolab.sym} 70 -5260 2 0 {name=r212}
C {devices/bus_connect_nolab.sym} 70 -5280 2 0 {name=r213}
C {devices/bus_connect_nolab.sym} 70 -5300 2 0 {name=r214}
C {devices/lab_wire.sym} 850 -5300 0 0 {name=l1087 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -5280 0 0 {name=l1088 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -5260 0 0 {name=l1089 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -5240 0 0 {name=l1090 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -5220 0 0 {name=l1091 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -5200 0 0 {name=l1092 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -5180 0 0 {name=l1093 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -5160 0 0 {name=l1094 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -5140 0 0 {name=l1095 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -5120 0 0 {name=l1096 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -5100 0 0 {name=l1097 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -5080 0 0 {name=l1098 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -5060 0 0 {name=l1099 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -5040 0 0 {name=l1100 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -5020 0 0 {name=l1101 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -4960 3 0 {name=l1102 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -5000 2 0 {name=r215}
C {devices/bus_connect_nolab.sym} 790 -5020 2 0 {name=r216}
C {devices/bus_connect_nolab.sym} 790 -5040 2 0 {name=r217}
C {devices/bus_connect_nolab.sym} 790 -5060 2 0 {name=r218}
C {devices/bus_connect_nolab.sym} 790 -5080 2 0 {name=r219}
C {devices/bus_connect_nolab.sym} 790 -5100 2 0 {name=r220}
C {devices/bus_connect_nolab.sym} 790 -5120 2 0 {name=r221}
C {devices/bus_connect_nolab.sym} 790 -5140 2 0 {name=r222}
C {devices/bus_connect_nolab.sym} 790 -5160 2 0 {name=r223}
C {devices/bus_connect_nolab.sym} 790 -5180 2 0 {name=r224}
C {devices/bus_connect_nolab.sym} 790 -5200 2 0 {name=r225}
C {devices/bus_connect_nolab.sym} 790 -5220 2 0 {name=r226}
C {devices/bus_connect_nolab.sym} 790 -5240 2 0 {name=r227}
C {devices/bus_connect_nolab.sym} 790 -5260 2 0 {name=r228}
C {devices/bus_connect_nolab.sym} 790 -5280 2 0 {name=r229}
C {devices/bus_connect_nolab.sym} 790 -5300 2 0 {name=r230}
C {devices/lab_wire.sym} 850 -5000 0 0 {name=l1103 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -5290 0 0 {name=l1104 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -5270 0 0 {name=l1105 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -5250 0 0 {name=l1106 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -5230 0 0 {name=l1107 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -5210 0 0 {name=l1108 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -5190 0 0 {name=l1109 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -5170 0 0 {name=l1110 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -5150 0 0 {name=l1111 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -5130 0 0 {name=l1112 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -5110 0 0 {name=l1113 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -5090 0 0 {name=l1114 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -5070 0 0 {name=l1115 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -5050 0 0 {name=l1116 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -5030 0 0 {name=l1117 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -5010 0 0 {name=l1118 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -4950 0 0 {name=l1119 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -4990 2 0 {name=r231}
C {devices/bus_connect_nolab.sym} 1490 -5010 2 0 {name=r232}
C {devices/bus_connect_nolab.sym} 1490 -5030 2 0 {name=r233}
C {devices/bus_connect_nolab.sym} 1490 -5050 2 0 {name=r234}
C {devices/bus_connect_nolab.sym} 1490 -5070 2 0 {name=r235}
C {devices/bus_connect_nolab.sym} 1490 -5090 2 0 {name=r236}
C {devices/bus_connect_nolab.sym} 1490 -5110 2 0 {name=r237}
C {devices/bus_connect_nolab.sym} 1490 -5130 2 0 {name=r238}
C {devices/bus_connect_nolab.sym} 1490 -5150 2 0 {name=r239}
C {devices/bus_connect_nolab.sym} 1490 -5170 2 0 {name=r240}
C {devices/bus_connect_nolab.sym} 1490 -5190 2 0 {name=r241}
C {devices/bus_connect_nolab.sym} 1490 -5210 2 0 {name=r242}
C {devices/bus_connect_nolab.sym} 1490 -5230 2 0 {name=r243}
C {devices/bus_connect_nolab.sym} 1490 -5250 2 0 {name=r244}
C {devices/bus_connect_nolab.sym} 1490 -5270 2 0 {name=r245}
C {devices/bus_connect_nolab.sym} 1490 -5290 2 0 {name=r246}
C {devices/lab_wire.sym} 1550 -4990 0 0 {name=l1120 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -5300 0 0 {name=l1121 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -5280 0 0 {name=l1122 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -5260 0 0 {name=l1123 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -5240 0 0 {name=l1124 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -5220 0 0 {name=l1125 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -5200 0 0 {name=l1126 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -5180 0 0 {name=l1127 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -5160 0 0 {name=l1128 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -5140 0 0 {name=l1129 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -5120 0 0 {name=l1130 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -5100 0 0 {name=l1131 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -5080 0 0 {name=l1132 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -5060 0 0 {name=l1133 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -5040 0 0 {name=l1134 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -5020 0 0 {name=l1135 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -4960 0 0 {name=l1136 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -5000 2 0 {name=r247}
C {devices/bus_connect_nolab.sym} 2220 -5020 2 0 {name=r248}
C {devices/bus_connect_nolab.sym} 2220 -5040 2 0 {name=r249}
C {devices/bus_connect_nolab.sym} 2220 -5060 2 0 {name=r250}
C {devices/bus_connect_nolab.sym} 2220 -5080 2 0 {name=r251}
C {devices/bus_connect_nolab.sym} 2220 -5100 2 0 {name=r252}
C {devices/bus_connect_nolab.sym} 2220 -5120 2 0 {name=r253}
C {devices/bus_connect_nolab.sym} 2220 -5140 2 0 {name=r254}
C {devices/bus_connect_nolab.sym} 2220 -5160 2 0 {name=r255}
C {devices/bus_connect_nolab.sym} 2220 -5180 2 0 {name=r256}
C {devices/bus_connect_nolab.sym} 2220 -5200 2 0 {name=r257}
C {devices/bus_connect_nolab.sym} 2220 -5220 2 0 {name=r258}
C {devices/bus_connect_nolab.sym} 2220 -5240 2 0 {name=r259}
C {devices/bus_connect_nolab.sym} 2220 -5260 2 0 {name=r260}
C {devices/bus_connect_nolab.sym} 2220 -5280 2 0 {name=r261}
C {devices/bus_connect_nolab.sym} 2220 -5300 2 0 {name=r262}
C {devices/lab_wire.sym} 2280 -5000 0 0 {name=l1137 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -5290 0 0 {name=l1138 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -5270 0 0 {name=l1139 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -5250 0 0 {name=l1140 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -5230 0 0 {name=l1141 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -5210 0 0 {name=l1142 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -5190 0 0 {name=l1143 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -5170 0 0 {name=l1144 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -5150 0 0 {name=l1145 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -5130 0 0 {name=l1146 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -5110 0 0 {name=l1147 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -5090 0 0 {name=l1148 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -5070 0 0 {name=l1149 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -5050 0 0 {name=l1150 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -5030 0 0 {name=l1151 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -5010 0 0 {name=l1152 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -4950 0 0 {name=l1153 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -4990 2 0 {name=r263}
C {devices/bus_connect_nolab.sym} 2920 -5010 2 0 {name=r264}
C {devices/bus_connect_nolab.sym} 2920 -5030 2 0 {name=r265}
C {devices/bus_connect_nolab.sym} 2920 -5050 2 0 {name=r266}
C {devices/bus_connect_nolab.sym} 2920 -5070 2 0 {name=r267}
C {devices/bus_connect_nolab.sym} 2920 -5090 2 0 {name=r268}
C {devices/bus_connect_nolab.sym} 2920 -5110 2 0 {name=r269}
C {devices/bus_connect_nolab.sym} 2920 -5130 2 0 {name=r270}
C {devices/bus_connect_nolab.sym} 2920 -5150 2 0 {name=r271}
C {devices/bus_connect_nolab.sym} 2920 -5170 2 0 {name=r272}
C {devices/bus_connect_nolab.sym} 2920 -5190 2 0 {name=r273}
C {devices/bus_connect_nolab.sym} 2920 -5210 2 0 {name=r274}
C {devices/bus_connect_nolab.sym} 2920 -5230 2 0 {name=r275}
C {devices/bus_connect_nolab.sym} 2920 -5250 2 0 {name=r276}
C {devices/bus_connect_nolab.sym} 2920 -5270 2 0 {name=r277}
C {devices/bus_connect_nolab.sym} 2920 -5290 2 0 {name=r278}
C {devices/lab_wire.sym} 2980 -4990 0 0 {name=l1154 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -5290 0 0 {name=l1155 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -5270 0 0 {name=l1156 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -5250 0 0 {name=l1157 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -5230 0 0 {name=l1158 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -5210 0 0 {name=l1159 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -5190 0 0 {name=l1160 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -5170 0 0 {name=l1161 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -5150 0 0 {name=l1162 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -5130 0 0 {name=l1163 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -5110 0 0 {name=l1164 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -5090 0 0 {name=l1165 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -5070 0 0 {name=l1166 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -5050 0 0 {name=l1167 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -5030 0 0 {name=l1168 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -5010 0 0 {name=l1169 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -4950 0 0 {name=l1170 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -4990 2 0 {name=r279}
C {devices/bus_connect_nolab.sym} 3630 -5010 2 0 {name=r280}
C {devices/bus_connect_nolab.sym} 3630 -5030 2 0 {name=r281}
C {devices/bus_connect_nolab.sym} 3630 -5050 2 0 {name=r282}
C {devices/bus_connect_nolab.sym} 3630 -5070 2 0 {name=r283}
C {devices/bus_connect_nolab.sym} 3630 -5090 2 0 {name=r284}
C {devices/bus_connect_nolab.sym} 3630 -5110 2 0 {name=r285}
C {devices/bus_connect_nolab.sym} 3630 -5130 2 0 {name=r286}
C {devices/bus_connect_nolab.sym} 3630 -5150 2 0 {name=r287}
C {devices/bus_connect_nolab.sym} 3630 -5170 2 0 {name=r288}
C {devices/bus_connect_nolab.sym} 3630 -5190 2 0 {name=r289}
C {devices/bus_connect_nolab.sym} 3630 -5210 2 0 {name=r290}
C {devices/bus_connect_nolab.sym} 3630 -5230 2 0 {name=r291}
C {devices/bus_connect_nolab.sym} 3630 -5250 2 0 {name=r292}
C {devices/bus_connect_nolab.sym} 3630 -5270 2 0 {name=r293}
C {devices/bus_connect_nolab.sym} 3630 -5290 2 0 {name=r294}
C {devices/lab_wire.sym} 3690 -4990 0 0 {name=l1171 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} 40 -5340 2 0 {name=r295}
C {devices/bus_connect_nolab.sym} 40 -5360 2 0 {name=r296}
C {devices/bus_connect_nolab.sym} 40 -5380 2 0 {name=r297}
C {devices/bus_connect_nolab.sym} 40 -5400 2 0 {name=r298}
C {devices/bus_connect_nolab.sym} 40 -5420 2 0 {name=r299}
C {devices/bus_connect_nolab.sym} 40 -5440 2 0 {name=r300}
C {devices/bus_connect_nolab.sym} 40 -5460 2 0 {name=r301}
C {devices/bus_connect_nolab.sym} 40 -5480 2 0 {name=r302}
C {devices/bus_connect_nolab.sym} 40 -5500 2 0 {name=r303}
C {devices/bus_connect_nolab.sym} 40 -5520 2 0 {name=r304}
C {devices/bus_connect_nolab.sym} 40 -5560 2 0 {name=r305}
C {devices/bus_connect_nolab.sym} 40 -5540 2 0 {name=r306}
C {devices/bus_connect_nolab.sym} 40 -5600 2 0 {name=r307}
C {devices/bus_connect_nolab.sym} 40 -5580 2 0 {name=r308}
C {devices/bus_connect_nolab.sym} 40 -5640 2 0 {name=r309}
C {devices/bus_connect_nolab.sym} 40 -5620 2 0 {name=r310}
C {devices/lab_wire.sym} 90 -5340 0 0 {name=l1172 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -5360 0 0 {name=l1173 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -5380 0 0 {name=l1174 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -5380 0 0 {name=l1175 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -5400 0 0 {name=l1176 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -5420 0 0 {name=l1177 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -5440 0 0 {name=l1178 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -5460 0 0 {name=l1179 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -5480 0 0 {name=l1180 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -5500 0 0 {name=l1181 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -5520 0 0 {name=l1182 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -5560 0 0 {name=l1183 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -5540 0 0 {name=l1184 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -5580 0 0 {name=l1185 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -5600 0 0 {name=l1186 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -5620 0 0 {name=l1187 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -5640 0 0 {name=l1188 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -5290 3 0 {name=l1189 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -5340 2 1 {name=r311}
C {devices/bus_connect_nolab.sym} 660 -5360 2 1 {name=r312}
C {devices/bus_connect_nolab.sym} 660 -5380 2 1 {name=r313}
C {devices/bus_connect_nolab.sym} 660 -5400 2 1 {name=r314}
C {devices/bus_connect_nolab.sym} 660 -5420 2 1 {name=r315}
C {devices/bus_connect_nolab.sym} 660 -5440 2 1 {name=r316}
C {devices/bus_connect_nolab.sym} 660 -5460 2 1 {name=r317}
C {devices/bus_connect_nolab.sym} 660 -5480 2 1 {name=r318}
C {devices/bus_connect_nolab.sym} 660 -5500 2 1 {name=r319}
C {devices/bus_connect_nolab.sym} 660 -5520 2 1 {name=r320}
C {devices/bus_connect_nolab.sym} 660 -5540 2 1 {name=r321}
C {devices/bus_connect_nolab.sym} 660 -5560 2 1 {name=r322}
C {devices/bus_connect_nolab.sym} 660 -5580 2 1 {name=r323}
C {devices/bus_connect_nolab.sym} 660 -5600 2 1 {name=r324}
C {devices/bus_connect_nolab.sym} 660 -5620 2 1 {name=r325}
C {devices/bus_connect_nolab.sym} 660 -5640 2 1 {name=r326}
C {devices/lab_pin.sym} 670 -5290 3 0 {name=l1190 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -5640 0 1 {name=l1191 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -5620 0 1 {name=l1192 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -5600 0 1 {name=l1193 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -5580 0 1 {name=l1194 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -5560 0 1 {name=l1195 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -5540 0 1 {name=l1196 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -5520 0 1 {name=l1197 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -5500 0 1 {name=l1198 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -5480 0 1 {name=l1199 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -5460 0 1 {name=l1200 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -5440 0 1 {name=l1201 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -5420 0 1 {name=l1202 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -5400 0 1 {name=l1203 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -5380 0 1 {name=l1204 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -5360 0 1 {name=l1205 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -5340 0 1 {name=l1206 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 190 -4660 2 0 {name=r327}
C {devices/bus_connect_nolab.sym} 190 -4680 2 0 {name=r328}
C {devices/bus_connect_nolab.sym} 190 -4700 2 0 {name=r329}
C {devices/bus_connect_nolab.sym} 190 -4720 2 0 {name=r330}
C {devices/bus_connect_nolab.sym} 190 -4740 2 0 {name=r331}
C {devices/bus_connect_nolab.sym} 190 -4760 2 0 {name=r332}
C {devices/bus_connect_nolab.sym} 190 -4780 2 0 {name=r333}
C {devices/bus_connect_nolab.sym} 190 -4800 2 0 {name=r334}
C {devices/bus_connect_nolab.sym} 190 -4820 2 0 {name=r335}
C {devices/bus_connect_nolab.sym} 190 -4840 2 0 {name=r336}
C {devices/bus_connect_nolab.sym} 190 -4860 2 0 {name=r337}
C {devices/bus_connect_nolab.sym} 190 -4880 2 0 {name=r338}
C {devices/bus_connect_nolab.sym} 190 -4900 2 0 {name=r339}
C {devices/bus_connect_nolab.sym} 190 -4920 2 0 {name=r340}
C {devices/bus_connect_nolab.sym} 190 -4940 2 0 {name=r341}
C {devices/bus_connect_nolab.sym} 190 -4960 2 0 {name=r342}
C {devices/lab_pin.sym} 180 -4620 3 0 {name=l1207 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -4660 2 1 {name=r343}
C {devices/bus_connect_nolab.sym} 610 -4680 2 1 {name=r344}
C {devices/bus_connect_nolab.sym} 610 -4700 2 1 {name=r345}
C {devices/bus_connect_nolab.sym} 610 -4720 2 1 {name=r346}
C {devices/bus_connect_nolab.sym} 610 -4740 2 1 {name=r347}
C {devices/bus_connect_nolab.sym} 610 -4760 2 1 {name=r348}
C {devices/bus_connect_nolab.sym} 610 -4780 2 1 {name=r349}
C {devices/bus_connect_nolab.sym} 610 -4800 2 1 {name=r350}
C {devices/bus_connect_nolab.sym} 610 -4820 2 1 {name=r351}
C {devices/bus_connect_nolab.sym} 610 -4840 2 1 {name=r352}
C {devices/bus_connect_nolab.sym} 610 -4860 2 1 {name=r353}
C {devices/bus_connect_nolab.sym} 610 -4880 2 1 {name=r354}
C {devices/bus_connect_nolab.sym} 610 -4900 2 1 {name=r355}
C {devices/bus_connect_nolab.sym} 610 -4920 2 1 {name=r356}
C {devices/bus_connect_nolab.sym} 610 -4940 2 1 {name=r357}
C {devices/bus_connect_nolab.sym} 610 -4960 2 1 {name=r358}
C {devices/lab_pin.sym} 620 -4620 1 1 {name=l1208 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -4680 0 0 {name=l1209 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -4700 0 0 {name=l1210 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -4720 0 0 {name=l1211 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -4740 0 0 {name=l1212 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -4760 0 0 {name=l1213 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -4780 0 0 {name=l1214 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -4800 0 0 {name=l1215 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -4820 0 0 {name=l1216 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -4840 0 0 {name=l1217 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -4880 0 0 {name=l1218 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -4860 0 0 {name=l1219 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -4900 0 0 {name=l1220 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -4920 0 0 {name=l1221 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -4940 0 0 {name=l1222 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -4960 0 0 {name=l1223 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -4660 0 0 {name=l1224 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -4680 0 1 {name=l1225 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -4700 0 1 {name=l1226 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -4720 0 1 {name=l1227 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -4740 0 1 {name=l1228 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -4760 0 1 {name=l1229 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -4780 0 1 {name=l1230 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -4800 0 1 {name=l1231 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -4820 0 1 {name=l1232 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -4840 0 1 {name=l1233 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -4880 0 1 {name=l1234 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -4860 0 1 {name=l1235 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -4900 0 1 {name=l1236 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -4920 0 1 {name=l1237 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -4940 0 1 {name=l1238 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -4960 0 1 {name=l1239 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -4660 0 1 {name=l1240 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -5940 0 0 {name=l1241 lab=row2_sel}
C {devices/lab_pin.sym} 910 -5920 0 0 {name=l1242 lab=col1_sel}
C {devices/bus_connect_nolab.sym} 760 -5340 2 0 {name=r359}
C {devices/bus_connect_nolab.sym} 760 -5360 2 0 {name=r360}
C {devices/bus_connect_nolab.sym} 760 -5380 2 0 {name=r361}
C {devices/bus_connect_nolab.sym} 760 -5400 2 0 {name=r362}
C {devices/bus_connect_nolab.sym} 760 -5420 2 0 {name=r363}
C {devices/bus_connect_nolab.sym} 760 -5440 2 0 {name=r364}
C {devices/bus_connect_nolab.sym} 760 -5460 2 0 {name=r365}
C {devices/bus_connect_nolab.sym} 760 -5480 2 0 {name=r366}
C {devices/bus_connect_nolab.sym} 760 -5500 2 0 {name=r367}
C {devices/bus_connect_nolab.sym} 760 -5520 2 0 {name=r368}
C {devices/bus_connect_nolab.sym} 760 -5560 2 0 {name=r369}
C {devices/bus_connect_nolab.sym} 760 -5540 2 0 {name=r370}
C {devices/bus_connect_nolab.sym} 760 -5600 2 0 {name=r371}
C {devices/bus_connect_nolab.sym} 760 -5580 2 0 {name=r372}
C {devices/bus_connect_nolab.sym} 760 -5640 2 0 {name=r373}
C {devices/bus_connect_nolab.sym} 760 -5620 2 0 {name=r374}
C {devices/lab_wire.sym} 810 -5340 0 0 {name=l1243 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -5360 0 0 {name=l1244 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -5380 0 0 {name=l1245 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -5380 0 0 {name=l1246 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -5400 0 0 {name=l1247 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -5420 0 0 {name=l1248 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -5440 0 0 {name=l1249 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -5460 0 0 {name=l1250 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -5480 0 0 {name=l1251 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -5500 0 0 {name=l1252 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -5520 0 0 {name=l1253 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -5560 0 0 {name=l1254 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -5540 0 0 {name=l1255 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -5580 0 0 {name=l1256 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -5600 0 0 {name=l1257 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -5620 0 0 {name=l1258 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -5640 0 0 {name=l1259 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -5290 3 0 {name=l1260 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -5340 2 1 {name=r375}
C {devices/bus_connect_nolab.sym} 1380 -5360 2 1 {name=r376}
C {devices/bus_connect_nolab.sym} 1380 -5380 2 1 {name=r377}
C {devices/bus_connect_nolab.sym} 1380 -5400 2 1 {name=r378}
C {devices/bus_connect_nolab.sym} 1380 -5420 2 1 {name=r379}
C {devices/bus_connect_nolab.sym} 1380 -5440 2 1 {name=r380}
C {devices/bus_connect_nolab.sym} 1380 -5460 2 1 {name=r381}
C {devices/bus_connect_nolab.sym} 1380 -5480 2 1 {name=r382}
C {devices/bus_connect_nolab.sym} 1380 -5500 2 1 {name=r383}
C {devices/bus_connect_nolab.sym} 1380 -5520 2 1 {name=r384}
C {devices/bus_connect_nolab.sym} 1380 -5540 2 1 {name=r385}
C {devices/bus_connect_nolab.sym} 1380 -5560 2 1 {name=r386}
C {devices/bus_connect_nolab.sym} 1380 -5580 2 1 {name=r387}
C {devices/bus_connect_nolab.sym} 1380 -5600 2 1 {name=r388}
C {devices/bus_connect_nolab.sym} 1380 -5620 2 1 {name=r389}
C {devices/bus_connect_nolab.sym} 1380 -5640 2 1 {name=r390}
C {devices/lab_pin.sym} 1390 -5290 3 0 {name=l1261 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -5640 0 1 {name=l1262 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -5620 0 1 {name=l1263 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -5600 0 1 {name=l1264 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -5580 0 1 {name=l1265 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -5560 0 1 {name=l1266 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -5540 0 1 {name=l1267 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -5520 0 1 {name=l1268 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -5500 0 1 {name=l1269 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -5480 0 1 {name=l1270 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -5460 0 1 {name=l1271 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -5440 0 1 {name=l1272 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -5420 0 1 {name=l1273 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -5400 0 1 {name=l1274 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -5380 0 1 {name=l1275 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -5360 0 1 {name=l1276 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -5340 0 1 {name=l1277 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -5860 0 0 {name=l1278 lab=Vgpr}
C {devices/lab_pin.sym} 910 -5900 0 0 {name=l1279 lab=Vgnr}
C {devices/lab_pin.sym} 910 -5880 0 0 {name=l1280 lab=WR}
C {devices/lab_pin.sym} 910 -5800 2 1 {name=l1281 lab=Vrplus}
C {devices/lab_pin.sym} 910 -5740 0 0 {name=l1282 lab=Vref}
C {devices/lab_pin.sym} 910 -5700 0 0 {name=l1283 lab=Vcplus}
C {devices/lab_pin.sym} 910 -5720 0 0 {name=l1284 lab=Vcminus}
C {devices/lab_pin.sym} 910 -5760 2 1 {name=l1285 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -5780 2 1 {name=l1286 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -5900 2 0 {name=l1287 lab=vdda1}
C {devices/lab_pin.sym} 1330 -5920 2 0 {name=l1289 lab=vccd1}
C {devices/lab_pin.sym} 1610 -5810 2 1 {name=l1290 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -5830 0 0 {name=l1291 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -5930 0 0 {name=l1292 lab=row2_sel}
C {devices/lab_pin.sym} 1610 -5910 0 0 {name=l1293 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -5850 0 0 {name=l1294 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -5890 0 0 {name=l1295 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -5870 0 0 {name=l1296 lab=WR}
C {devices/lab_pin.sym} 1610 -5790 2 1 {name=l1297 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -5730 0 0 {name=l1298 lab=Vref}
C {devices/lab_pin.sym} 1610 -5690 0 0 {name=l1299 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -5710 0 0 {name=l1300 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -5750 2 1 {name=l1301 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -5770 2 1 {name=l1302 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -5890 2 0 {name=l1303 lab=vdda1}
C {devices/lab_pin.sym} 2030 -5910 2 0 {name=l1305 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -5330 2 0 {name=r391}
C {devices/bus_connect_nolab.sym} 1460 -5350 2 0 {name=r392}
C {devices/bus_connect_nolab.sym} 1460 -5370 2 0 {name=r393}
C {devices/bus_connect_nolab.sym} 1460 -5390 2 0 {name=r394}
C {devices/bus_connect_nolab.sym} 1460 -5410 2 0 {name=r395}
C {devices/bus_connect_nolab.sym} 1460 -5430 2 0 {name=r396}
C {devices/bus_connect_nolab.sym} 1460 -5450 2 0 {name=r397}
C {devices/bus_connect_nolab.sym} 1460 -5470 2 0 {name=r398}
C {devices/bus_connect_nolab.sym} 1460 -5490 2 0 {name=r399}
C {devices/bus_connect_nolab.sym} 1460 -5510 2 0 {name=r400}
C {devices/bus_connect_nolab.sym} 1460 -5550 2 0 {name=r401}
C {devices/bus_connect_nolab.sym} 1460 -5530 2 0 {name=r402}
C {devices/bus_connect_nolab.sym} 1460 -5590 2 0 {name=r403}
C {devices/bus_connect_nolab.sym} 1460 -5570 2 0 {name=r404}
C {devices/bus_connect_nolab.sym} 1460 -5630 2 0 {name=r405}
C {devices/bus_connect_nolab.sym} 1460 -5610 2 0 {name=r406}
C {devices/lab_wire.sym} 1510 -5330 0 0 {name=l1306 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -5350 0 0 {name=l1307 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -5370 0 0 {name=l1308 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -5370 0 0 {name=l1309 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -5390 0 0 {name=l1310 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -5410 0 0 {name=l1311 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -5430 0 0 {name=l1312 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -5450 0 0 {name=l1313 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -5470 0 0 {name=l1314 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -5490 0 0 {name=l1315 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -5510 0 0 {name=l1316 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -5550 0 0 {name=l1317 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -5530 0 0 {name=l1318 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -5570 0 0 {name=l1319 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -5590 0 0 {name=l1320 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -5610 0 0 {name=l1321 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -5630 0 0 {name=l1322 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -5280 3 0 {name=l1323 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -5330 2 1 {name=r407}
C {devices/bus_connect_nolab.sym} 2080 -5350 2 1 {name=r408}
C {devices/bus_connect_nolab.sym} 2080 -5370 2 1 {name=r409}
C {devices/bus_connect_nolab.sym} 2080 -5390 2 1 {name=r410}
C {devices/bus_connect_nolab.sym} 2080 -5410 2 1 {name=r411}
C {devices/bus_connect_nolab.sym} 2080 -5430 2 1 {name=r412}
C {devices/bus_connect_nolab.sym} 2080 -5450 2 1 {name=r413}
C {devices/bus_connect_nolab.sym} 2080 -5470 2 1 {name=r414}
C {devices/bus_connect_nolab.sym} 2080 -5490 2 1 {name=r415}
C {devices/bus_connect_nolab.sym} 2080 -5510 2 1 {name=r416}
C {devices/bus_connect_nolab.sym} 2080 -5530 2 1 {name=r417}
C {devices/bus_connect_nolab.sym} 2080 -5550 2 1 {name=r418}
C {devices/bus_connect_nolab.sym} 2080 -5570 2 1 {name=r419}
C {devices/bus_connect_nolab.sym} 2080 -5590 2 1 {name=r420}
C {devices/bus_connect_nolab.sym} 2080 -5610 2 1 {name=r421}
C {devices/bus_connect_nolab.sym} 2080 -5630 2 1 {name=r422}
C {devices/lab_pin.sym} 2090 -5280 3 0 {name=l1324 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -5630 0 1 {name=l1325 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -5610 0 1 {name=l1326 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -5590 0 1 {name=l1327 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -5570 0 1 {name=l1328 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -5550 0 1 {name=l1329 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -5530 0 1 {name=l1330 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -5510 0 1 {name=l1331 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -5490 0 1 {name=l1332 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -5470 0 1 {name=l1333 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -5450 0 1 {name=l1334 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -5430 0 1 {name=l1335 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -5410 0 1 {name=l1336 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -5390 0 1 {name=l1337 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -5370 0 1 {name=l1338 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -5350 0 1 {name=l1339 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -5330 0 1 {name=l1340 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -4660 2 0 {name=r423}
C {devices/bus_connect_nolab.sym} 910 -4680 2 0 {name=r424}
C {devices/bus_connect_nolab.sym} 910 -4700 2 0 {name=r425}
C {devices/bus_connect_nolab.sym} 910 -4720 2 0 {name=r426}
C {devices/bus_connect_nolab.sym} 910 -4740 2 0 {name=r427}
C {devices/bus_connect_nolab.sym} 910 -4760 2 0 {name=r428}
C {devices/bus_connect_nolab.sym} 910 -4780 2 0 {name=r429}
C {devices/bus_connect_nolab.sym} 910 -4800 2 0 {name=r430}
C {devices/bus_connect_nolab.sym} 910 -4820 2 0 {name=r431}
C {devices/bus_connect_nolab.sym} 910 -4840 2 0 {name=r432}
C {devices/bus_connect_nolab.sym} 910 -4860 2 0 {name=r433}
C {devices/bus_connect_nolab.sym} 910 -4880 2 0 {name=r434}
C {devices/bus_connect_nolab.sym} 910 -4900 2 0 {name=r435}
C {devices/bus_connect_nolab.sym} 910 -4920 2 0 {name=r436}
C {devices/bus_connect_nolab.sym} 910 -4940 2 0 {name=r437}
C {devices/bus_connect_nolab.sym} 910 -4960 2 0 {name=r438}
C {devices/lab_pin.sym} 900 -4620 3 0 {name=l1341 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -4660 2 1 {name=r439}
C {devices/bus_connect_nolab.sym} 1330 -4680 2 1 {name=r440}
C {devices/bus_connect_nolab.sym} 1330 -4700 2 1 {name=r441}
C {devices/bus_connect_nolab.sym} 1330 -4720 2 1 {name=r442}
C {devices/bus_connect_nolab.sym} 1330 -4740 2 1 {name=r443}
C {devices/bus_connect_nolab.sym} 1330 -4760 2 1 {name=r444}
C {devices/bus_connect_nolab.sym} 1330 -4780 2 1 {name=r445}
C {devices/bus_connect_nolab.sym} 1330 -4800 2 1 {name=r446}
C {devices/bus_connect_nolab.sym} 1330 -4820 2 1 {name=r447}
C {devices/bus_connect_nolab.sym} 1330 -4840 2 1 {name=r448}
C {devices/bus_connect_nolab.sym} 1330 -4860 2 1 {name=r449}
C {devices/bus_connect_nolab.sym} 1330 -4880 2 1 {name=r450}
C {devices/bus_connect_nolab.sym} 1330 -4900 2 1 {name=r451}
C {devices/bus_connect_nolab.sym} 1330 -4920 2 1 {name=r452}
C {devices/bus_connect_nolab.sym} 1330 -4940 2 1 {name=r453}
C {devices/bus_connect_nolab.sym} 1330 -4960 2 1 {name=r454}
C {devices/lab_pin.sym} 1340 -4620 1 1 {name=l1342 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -4680 0 0 {name=l1343 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -4700 0 0 {name=l1344 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -4720 0 0 {name=l1345 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -4740 0 0 {name=l1346 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -4760 0 0 {name=l1347 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -4780 0 0 {name=l1348 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -4800 0 0 {name=l1349 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -4820 0 0 {name=l1350 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -4840 0 0 {name=l1351 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -4880 0 0 {name=l1352 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -4860 0 0 {name=l1353 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -4900 0 0 {name=l1354 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -4920 0 0 {name=l1355 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -4940 0 0 {name=l1356 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -4960 0 0 {name=l1357 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -4660 0 0 {name=l1358 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -4680 0 1 {name=l1359 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -4700 0 1 {name=l1360 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -4720 0 1 {name=l1361 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -4740 0 1 {name=l1362 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -4760 0 1 {name=l1363 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -4780 0 1 {name=l1364 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -4800 0 1 {name=l1365 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -4820 0 1 {name=l1366 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -4840 0 1 {name=l1367 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -4880 0 1 {name=l1368 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -4860 0 1 {name=l1369 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -4900 0 1 {name=l1370 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -4920 0 1 {name=l1371 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -4940 0 1 {name=l1372 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -4960 0 1 {name=l1373 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -4660 0 1 {name=l1374 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -4650 2 0 {name=r455}
C {devices/bus_connect_nolab.sym} 1610 -4670 2 0 {name=r456}
C {devices/bus_connect_nolab.sym} 1610 -4690 2 0 {name=r457}
C {devices/bus_connect_nolab.sym} 1610 -4710 2 0 {name=r458}
C {devices/bus_connect_nolab.sym} 1610 -4730 2 0 {name=r459}
C {devices/bus_connect_nolab.sym} 1610 -4750 2 0 {name=r460}
C {devices/bus_connect_nolab.sym} 1610 -4770 2 0 {name=r461}
C {devices/bus_connect_nolab.sym} 1610 -4790 2 0 {name=r462}
C {devices/bus_connect_nolab.sym} 1610 -4810 2 0 {name=r463}
C {devices/bus_connect_nolab.sym} 1610 -4830 2 0 {name=r464}
C {devices/bus_connect_nolab.sym} 1610 -4850 2 0 {name=r465}
C {devices/bus_connect_nolab.sym} 1610 -4870 2 0 {name=r466}
C {devices/bus_connect_nolab.sym} 1610 -4890 2 0 {name=r467}
C {devices/bus_connect_nolab.sym} 1610 -4910 2 0 {name=r468}
C {devices/bus_connect_nolab.sym} 1610 -4930 2 0 {name=r469}
C {devices/bus_connect_nolab.sym} 1610 -4950 2 0 {name=r470}
C {devices/lab_pin.sym} 1600 -4610 3 0 {name=l1375 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -4650 2 1 {name=r471}
C {devices/bus_connect_nolab.sym} 2030 -4670 2 1 {name=r472}
C {devices/bus_connect_nolab.sym} 2030 -4690 2 1 {name=r473}
C {devices/bus_connect_nolab.sym} 2030 -4710 2 1 {name=r474}
C {devices/bus_connect_nolab.sym} 2030 -4730 2 1 {name=r475}
C {devices/bus_connect_nolab.sym} 2030 -4750 2 1 {name=r476}
C {devices/bus_connect_nolab.sym} 2030 -4770 2 1 {name=r477}
C {devices/bus_connect_nolab.sym} 2030 -4790 2 1 {name=r478}
C {devices/bus_connect_nolab.sym} 2030 -4810 2 1 {name=r479}
C {devices/bus_connect_nolab.sym} 2030 -4830 2 1 {name=r480}
C {devices/bus_connect_nolab.sym} 2030 -4850 2 1 {name=r481}
C {devices/bus_connect_nolab.sym} 2030 -4870 2 1 {name=r482}
C {devices/bus_connect_nolab.sym} 2030 -4890 2 1 {name=r483}
C {devices/bus_connect_nolab.sym} 2030 -4910 2 1 {name=r484}
C {devices/bus_connect_nolab.sym} 2030 -4930 2 1 {name=r485}
C {devices/bus_connect_nolab.sym} 2030 -4950 2 1 {name=r486}
C {devices/lab_pin.sym} 2040 -4610 1 1 {name=l1376 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -4670 0 0 {name=l1377 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -4690 0 0 {name=l1378 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -4710 0 0 {name=l1379 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -4730 0 0 {name=l1380 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -4750 0 0 {name=l1381 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -4770 0 0 {name=l1382 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -4790 0 0 {name=l1383 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -4810 0 0 {name=l1384 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -4830 0 0 {name=l1385 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -4870 0 0 {name=l1386 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -4850 0 0 {name=l1387 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -4890 0 0 {name=l1388 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -4910 0 0 {name=l1389 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -4930 0 0 {name=l1390 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -4950 0 0 {name=l1391 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -4650 0 0 {name=l1392 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -4670 0 1 {name=l1393 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -4690 0 1 {name=l1394 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -4710 0 1 {name=l1395 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -4730 0 1 {name=l1396 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -4750 0 1 {name=l1397 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -4770 0 1 {name=l1398 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -4790 0 1 {name=l1399 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -4810 0 1 {name=l1400 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -4830 0 1 {name=l1401 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -4870 0 1 {name=l1402 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -4850 0 1 {name=l1403 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -4890 0 1 {name=l1404 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -4910 0 1 {name=l1405 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -4930 0 1 {name=l1406 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -4950 0 1 {name=l1407 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -4650 0 1 {name=l1408 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -5340 2 0 {name=r487}
C {devices/bus_connect_nolab.sym} 2190 -5360 2 0 {name=r488}
C {devices/bus_connect_nolab.sym} 2190 -5380 2 0 {name=r489}
C {devices/bus_connect_nolab.sym} 2190 -5400 2 0 {name=r490}
C {devices/bus_connect_nolab.sym} 2190 -5420 2 0 {name=r491}
C {devices/bus_connect_nolab.sym} 2190 -5440 2 0 {name=r492}
C {devices/bus_connect_nolab.sym} 2190 -5460 2 0 {name=r493}
C {devices/bus_connect_nolab.sym} 2190 -5480 2 0 {name=r494}
C {devices/bus_connect_nolab.sym} 2190 -5500 2 0 {name=r495}
C {devices/bus_connect_nolab.sym} 2190 -5520 2 0 {name=r496}
C {devices/bus_connect_nolab.sym} 2190 -5560 2 0 {name=r497}
C {devices/bus_connect_nolab.sym} 2190 -5540 2 0 {name=r498}
C {devices/bus_connect_nolab.sym} 2190 -5600 2 0 {name=r499}
C {devices/bus_connect_nolab.sym} 2190 -5580 2 0 {name=r500}
C {devices/bus_connect_nolab.sym} 2190 -5640 2 0 {name=r501}
C {devices/bus_connect_nolab.sym} 2190 -5620 2 0 {name=r502}
C {devices/lab_wire.sym} 2240 -5340 0 0 {name=l1409 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -5360 0 0 {name=l1410 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -5380 0 0 {name=l1411 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -5380 0 0 {name=l1412 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -5400 0 0 {name=l1413 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -5420 0 0 {name=l1414 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -5440 0 0 {name=l1415 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -5460 0 0 {name=l1416 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -5480 0 0 {name=l1417 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -5500 0 0 {name=l1418 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -5520 0 0 {name=l1419 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -5560 0 0 {name=l1420 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -5540 0 0 {name=l1421 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -5580 0 0 {name=l1422 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -5600 0 0 {name=l1423 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -5620 0 0 {name=l1424 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -5640 0 0 {name=l1425 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -5290 3 0 {name=l1426 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -5340 2 1 {name=r503}
C {devices/bus_connect_nolab.sym} 2810 -5360 2 1 {name=r504}
C {devices/bus_connect_nolab.sym} 2810 -5380 2 1 {name=r505}
C {devices/bus_connect_nolab.sym} 2810 -5400 2 1 {name=r506}
C {devices/bus_connect_nolab.sym} 2810 -5420 2 1 {name=r507}
C {devices/bus_connect_nolab.sym} 2810 -5440 2 1 {name=r508}
C {devices/bus_connect_nolab.sym} 2810 -5460 2 1 {name=r509}
C {devices/bus_connect_nolab.sym} 2810 -5480 2 1 {name=r510}
C {devices/bus_connect_nolab.sym} 2810 -5500 2 1 {name=r511}
C {devices/bus_connect_nolab.sym} 2810 -5520 2 1 {name=r512}
C {devices/bus_connect_nolab.sym} 2810 -5540 2 1 {name=r513}
C {devices/bus_connect_nolab.sym} 2810 -5560 2 1 {name=r514}
C {devices/bus_connect_nolab.sym} 2810 -5580 2 1 {name=r515}
C {devices/bus_connect_nolab.sym} 2810 -5600 2 1 {name=r516}
C {devices/bus_connect_nolab.sym} 2810 -5620 2 1 {name=r517}
C {devices/bus_connect_nolab.sym} 2810 -5640 2 1 {name=r518}
C {devices/lab_pin.sym} 2820 -5290 3 0 {name=l1427 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -5640 0 1 {name=l1428 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -5620 0 1 {name=l1429 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -5600 0 1 {name=l1430 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -5580 0 1 {name=l1431 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -5560 0 1 {name=l1432 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -5540 0 1 {name=l1433 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -5520 0 1 {name=l1434 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -5500 0 1 {name=l1435 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -5480 0 1 {name=l1436 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -5460 0 1 {name=l1437 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -5440 0 1 {name=l1438 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -5420 0 1 {name=l1439 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -5400 0 1 {name=l1440 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -5380 0 1 {name=l1441 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -5360 0 1 {name=l1442 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -5340 0 1 {name=l1443 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -4660 2 0 {name=r519}
C {devices/bus_connect_nolab.sym} 2340 -4680 2 0 {name=r520}
C {devices/bus_connect_nolab.sym} 2340 -4700 2 0 {name=r521}
C {devices/bus_connect_nolab.sym} 2340 -4720 2 0 {name=r522}
C {devices/bus_connect_nolab.sym} 2340 -4740 2 0 {name=r523}
C {devices/bus_connect_nolab.sym} 2340 -4760 2 0 {name=r524}
C {devices/bus_connect_nolab.sym} 2340 -4780 2 0 {name=r525}
C {devices/bus_connect_nolab.sym} 2340 -4800 2 0 {name=r526}
C {devices/bus_connect_nolab.sym} 2340 -4820 2 0 {name=r527}
C {devices/bus_connect_nolab.sym} 2340 -4840 2 0 {name=r528}
C {devices/bus_connect_nolab.sym} 2340 -4860 2 0 {name=r529}
C {devices/bus_connect_nolab.sym} 2340 -4880 2 0 {name=r530}
C {devices/bus_connect_nolab.sym} 2340 -4900 2 0 {name=r531}
C {devices/bus_connect_nolab.sym} 2340 -4920 2 0 {name=r532}
C {devices/bus_connect_nolab.sym} 2340 -4940 2 0 {name=r533}
C {devices/bus_connect_nolab.sym} 2340 -4960 2 0 {name=r534}
C {devices/lab_pin.sym} 2330 -4620 3 0 {name=l1444 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -4660 2 1 {name=r535}
C {devices/bus_connect_nolab.sym} 2760 -4680 2 1 {name=r536}
C {devices/bus_connect_nolab.sym} 2760 -4700 2 1 {name=r537}
C {devices/bus_connect_nolab.sym} 2760 -4720 2 1 {name=r538}
C {devices/bus_connect_nolab.sym} 2760 -4740 2 1 {name=r539}
C {devices/bus_connect_nolab.sym} 2760 -4760 2 1 {name=r540}
C {devices/bus_connect_nolab.sym} 2760 -4780 2 1 {name=r541}
C {devices/bus_connect_nolab.sym} 2760 -4800 2 1 {name=r542}
C {devices/bus_connect_nolab.sym} 2760 -4820 2 1 {name=r543}
C {devices/bus_connect_nolab.sym} 2760 -4840 2 1 {name=r544}
C {devices/bus_connect_nolab.sym} 2760 -4860 2 1 {name=r545}
C {devices/bus_connect_nolab.sym} 2760 -4880 2 1 {name=r546}
C {devices/bus_connect_nolab.sym} 2760 -4900 2 1 {name=r547}
C {devices/bus_connect_nolab.sym} 2760 -4920 2 1 {name=r548}
C {devices/bus_connect_nolab.sym} 2760 -4940 2 1 {name=r549}
C {devices/bus_connect_nolab.sym} 2760 -4960 2 1 {name=r550}
C {devices/lab_pin.sym} 2770 -4620 1 1 {name=l1445 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -4680 0 0 {name=l1446 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -4700 0 0 {name=l1447 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -4720 0 0 {name=l1448 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -4740 0 0 {name=l1449 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -4760 0 0 {name=l1450 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -4780 0 0 {name=l1451 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -4800 0 0 {name=l1452 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -4820 0 0 {name=l1453 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -4840 0 0 {name=l1454 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -4880 0 0 {name=l1455 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -4860 0 0 {name=l1456 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -4900 0 0 {name=l1457 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -4920 0 0 {name=l1458 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -4940 0 0 {name=l1459 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -4960 0 0 {name=l1460 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -4660 0 0 {name=l1461 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -4680 0 1 {name=l1462 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -4700 0 1 {name=l1463 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -4720 0 1 {name=l1464 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -4740 0 1 {name=l1465 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -4760 0 1 {name=l1466 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -4780 0 1 {name=l1467 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -4800 0 1 {name=l1468 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -4820 0 1 {name=l1469 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -4840 0 1 {name=l1470 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -4880 0 1 {name=l1471 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -4860 0 1 {name=l1472 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -4900 0 1 {name=l1473 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -4920 0 1 {name=l1474 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -4940 0 1 {name=l1475 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -4960 0 1 {name=l1476 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -4660 0 1 {name=l1477 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -5330 2 0 {name=r551}
C {devices/bus_connect_nolab.sym} 2890 -5350 2 0 {name=r552}
C {devices/bus_connect_nolab.sym} 2890 -5370 2 0 {name=r553}
C {devices/bus_connect_nolab.sym} 2890 -5390 2 0 {name=r554}
C {devices/bus_connect_nolab.sym} 2890 -5410 2 0 {name=r555}
C {devices/bus_connect_nolab.sym} 2890 -5430 2 0 {name=r556}
C {devices/bus_connect_nolab.sym} 2890 -5450 2 0 {name=r557}
C {devices/bus_connect_nolab.sym} 2890 -5470 2 0 {name=r558}
C {devices/bus_connect_nolab.sym} 2890 -5490 2 0 {name=r559}
C {devices/bus_connect_nolab.sym} 2890 -5510 2 0 {name=r560}
C {devices/bus_connect_nolab.sym} 2890 -5550 2 0 {name=r561}
C {devices/bus_connect_nolab.sym} 2890 -5530 2 0 {name=r562}
C {devices/bus_connect_nolab.sym} 2890 -5590 2 0 {name=r563}
C {devices/bus_connect_nolab.sym} 2890 -5570 2 0 {name=r564}
C {devices/bus_connect_nolab.sym} 2890 -5630 2 0 {name=r565}
C {devices/bus_connect_nolab.sym} 2890 -5610 2 0 {name=r566}
C {devices/lab_wire.sym} 2940 -5330 0 0 {name=l1478 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -5350 0 0 {name=l1479 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -5370 0 0 {name=l1480 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -5370 0 0 {name=l1481 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -5390 0 0 {name=l1482 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -5410 0 0 {name=l1483 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -5430 0 0 {name=l1484 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -5450 0 0 {name=l1485 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -5470 0 0 {name=l1486 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -5490 0 0 {name=l1487 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -5510 0 0 {name=l1488 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -5550 0 0 {name=l1489 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -5530 0 0 {name=l1490 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -5570 0 0 {name=l1491 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -5590 0 0 {name=l1492 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -5610 0 0 {name=l1493 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -5630 0 0 {name=l1494 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -5280 3 0 {name=l1495 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -5330 2 1 {name=r567}
C {devices/bus_connect_nolab.sym} 3510 -5350 2 1 {name=r568}
C {devices/bus_connect_nolab.sym} 3510 -5370 2 1 {name=r569}
C {devices/bus_connect_nolab.sym} 3510 -5390 2 1 {name=r570}
C {devices/bus_connect_nolab.sym} 3510 -5410 2 1 {name=r571}
C {devices/bus_connect_nolab.sym} 3510 -5430 2 1 {name=r572}
C {devices/bus_connect_nolab.sym} 3510 -5450 2 1 {name=r573}
C {devices/bus_connect_nolab.sym} 3510 -5470 2 1 {name=r574}
C {devices/bus_connect_nolab.sym} 3510 -5490 2 1 {name=r575}
C {devices/bus_connect_nolab.sym} 3510 -5510 2 1 {name=r576}
C {devices/bus_connect_nolab.sym} 3510 -5530 2 1 {name=r577}
C {devices/bus_connect_nolab.sym} 3510 -5550 2 1 {name=r578}
C {devices/bus_connect_nolab.sym} 3510 -5570 2 1 {name=r579}
C {devices/bus_connect_nolab.sym} 3510 -5590 2 1 {name=r580}
C {devices/bus_connect_nolab.sym} 3510 -5610 2 1 {name=r581}
C {devices/bus_connect_nolab.sym} 3510 -5630 2 1 {name=r582}
C {devices/lab_pin.sym} 3520 -5280 3 0 {name=l1496 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -5630 0 1 {name=l1497 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -5610 0 1 {name=l1498 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -5590 0 1 {name=l1499 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -5570 0 1 {name=l1500 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -5550 0 1 {name=l1501 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -5530 0 1 {name=l1502 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -5510 0 1 {name=l1503 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -5490 0 1 {name=l1504 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -5470 0 1 {name=l1505 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -5450 0 1 {name=l1506 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -5430 0 1 {name=l1507 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -5410 0 1 {name=l1508 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -5390 0 1 {name=l1509 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -5370 0 1 {name=l1510 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -5350 0 1 {name=l1511 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -5330 0 1 {name=l1512 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -4650 2 0 {name=r583}
C {devices/bus_connect_nolab.sym} 3040 -4670 2 0 {name=r584}
C {devices/bus_connect_nolab.sym} 3040 -4690 2 0 {name=r585}
C {devices/bus_connect_nolab.sym} 3040 -4710 2 0 {name=r586}
C {devices/bus_connect_nolab.sym} 3040 -4730 2 0 {name=r587}
C {devices/bus_connect_nolab.sym} 3040 -4750 2 0 {name=r588}
C {devices/bus_connect_nolab.sym} 3040 -4770 2 0 {name=r589}
C {devices/bus_connect_nolab.sym} 3040 -4790 2 0 {name=r590}
C {devices/bus_connect_nolab.sym} 3040 -4810 2 0 {name=r591}
C {devices/bus_connect_nolab.sym} 3040 -4830 2 0 {name=r592}
C {devices/bus_connect_nolab.sym} 3040 -4850 2 0 {name=r593}
C {devices/bus_connect_nolab.sym} 3040 -4870 2 0 {name=r594}
C {devices/bus_connect_nolab.sym} 3040 -4890 2 0 {name=r595}
C {devices/bus_connect_nolab.sym} 3040 -4910 2 0 {name=r596}
C {devices/bus_connect_nolab.sym} 3040 -4930 2 0 {name=r597}
C {devices/bus_connect_nolab.sym} 3040 -4950 2 0 {name=r598}
C {devices/lab_pin.sym} 3030 -4610 3 0 {name=l1513 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -4650 2 1 {name=r599}
C {devices/bus_connect_nolab.sym} 3460 -4670 2 1 {name=r600}
C {devices/bus_connect_nolab.sym} 3460 -4690 2 1 {name=r601}
C {devices/bus_connect_nolab.sym} 3460 -4710 2 1 {name=r602}
C {devices/bus_connect_nolab.sym} 3460 -4730 2 1 {name=r603}
C {devices/bus_connect_nolab.sym} 3460 -4750 2 1 {name=r604}
C {devices/bus_connect_nolab.sym} 3460 -4770 2 1 {name=r605}
C {devices/bus_connect_nolab.sym} 3460 -4790 2 1 {name=r606}
C {devices/bus_connect_nolab.sym} 3460 -4810 2 1 {name=r607}
C {devices/bus_connect_nolab.sym} 3460 -4830 2 1 {name=r608}
C {devices/bus_connect_nolab.sym} 3460 -4850 2 1 {name=r609}
C {devices/bus_connect_nolab.sym} 3460 -4870 2 1 {name=r610}
C {devices/bus_connect_nolab.sym} 3460 -4890 2 1 {name=r611}
C {devices/bus_connect_nolab.sym} 3460 -4910 2 1 {name=r612}
C {devices/bus_connect_nolab.sym} 3460 -4930 2 1 {name=r613}
C {devices/bus_connect_nolab.sym} 3460 -4950 2 1 {name=r614}
C {devices/lab_pin.sym} 3470 -4610 1 1 {name=l1514 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -4670 0 0 {name=l1515 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -4690 0 0 {name=l1516 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -4710 0 0 {name=l1517 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -4730 0 0 {name=l1518 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -4750 0 0 {name=l1519 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -4770 0 0 {name=l1520 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -4790 0 0 {name=l1521 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -4810 0 0 {name=l1522 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -4830 0 0 {name=l1523 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -4870 0 0 {name=l1524 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -4850 0 0 {name=l1525 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -4890 0 0 {name=l1526 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -4910 0 0 {name=l1527 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -4930 0 0 {name=l1528 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -4950 0 0 {name=l1529 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -4650 0 0 {name=l1530 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -4670 0 1 {name=l1531 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -4690 0 1 {name=l1532 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -4710 0 1 {name=l1533 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -4730 0 1 {name=l1534 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -4750 0 1 {name=l1535 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -4770 0 1 {name=l1536 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -4790 0 1 {name=l1537 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -4810 0 1 {name=l1538 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -4830 0 1 {name=l1539 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -4870 0 1 {name=l1540 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -4850 0 1 {name=l1541 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -4890 0 1 {name=l1542 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -4910 0 1 {name=l1543 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -4930 0 1 {name=l1544 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -4950 0 1 {name=l1545 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -4650 0 1 {name=l1546 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -5330 2 0 {name=r615}
C {devices/bus_connect_nolab.sym} 3600 -5350 2 0 {name=r616}
C {devices/bus_connect_nolab.sym} 3600 -5370 2 0 {name=r617}
C {devices/bus_connect_nolab.sym} 3600 -5390 2 0 {name=r618}
C {devices/bus_connect_nolab.sym} 3600 -5410 2 0 {name=r619}
C {devices/bus_connect_nolab.sym} 3600 -5430 2 0 {name=r620}
C {devices/bus_connect_nolab.sym} 3600 -5450 2 0 {name=r621}
C {devices/bus_connect_nolab.sym} 3600 -5470 2 0 {name=r622}
C {devices/bus_connect_nolab.sym} 3600 -5490 2 0 {name=r623}
C {devices/bus_connect_nolab.sym} 3600 -5510 2 0 {name=r624}
C {devices/bus_connect_nolab.sym} 3600 -5550 2 0 {name=r625}
C {devices/bus_connect_nolab.sym} 3600 -5530 2 0 {name=r626}
C {devices/bus_connect_nolab.sym} 3600 -5590 2 0 {name=r627}
C {devices/bus_connect_nolab.sym} 3600 -5570 2 0 {name=r628}
C {devices/bus_connect_nolab.sym} 3600 -5630 2 0 {name=r629}
C {devices/bus_connect_nolab.sym} 3600 -5610 2 0 {name=r630}
C {devices/lab_wire.sym} 3650 -5330 0 0 {name=l1547 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -5350 0 0 {name=l1548 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -5370 0 0 {name=l1549 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -5370 0 0 {name=l1550 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -5390 0 0 {name=l1551 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -5410 0 0 {name=l1552 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -5430 0 0 {name=l1553 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -5450 0 0 {name=l1554 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -5470 0 0 {name=l1555 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -5490 0 0 {name=l1556 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -5510 0 0 {name=l1557 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -5550 0 0 {name=l1558 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -5530 0 0 {name=l1559 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -5570 0 0 {name=l1560 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -5590 0 0 {name=l1561 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -5610 0 0 {name=l1562 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -5630 0 0 {name=l1563 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -5280 3 0 {name=l1564 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -5330 2 1 {name=r631}
C {devices/bus_connect_nolab.sym} 4220 -5350 2 1 {name=r632}
C {devices/bus_connect_nolab.sym} 4220 -5370 2 1 {name=r633}
C {devices/bus_connect_nolab.sym} 4220 -5390 2 1 {name=r634}
C {devices/bus_connect_nolab.sym} 4220 -5410 2 1 {name=r635}
C {devices/bus_connect_nolab.sym} 4220 -5430 2 1 {name=r636}
C {devices/bus_connect_nolab.sym} 4220 -5450 2 1 {name=r637}
C {devices/bus_connect_nolab.sym} 4220 -5470 2 1 {name=r638}
C {devices/bus_connect_nolab.sym} 4220 -5490 2 1 {name=r639}
C {devices/bus_connect_nolab.sym} 4220 -5510 2 1 {name=r640}
C {devices/bus_connect_nolab.sym} 4220 -5530 2 1 {name=r641}
C {devices/bus_connect_nolab.sym} 4220 -5550 2 1 {name=r642}
C {devices/bus_connect_nolab.sym} 4220 -5570 2 1 {name=r643}
C {devices/bus_connect_nolab.sym} 4220 -5590 2 1 {name=r644}
C {devices/bus_connect_nolab.sym} 4220 -5610 2 1 {name=r645}
C {devices/bus_connect_nolab.sym} 4220 -5630 2 1 {name=r646}
C {devices/lab_pin.sym} 4230 -5280 3 0 {name=l1565 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -5630 0 1 {name=l1566 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -5610 0 1 {name=l1567 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -5590 0 1 {name=l1568 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -5570 0 1 {name=l1569 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -5550 0 1 {name=l1570 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -5530 0 1 {name=l1571 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -5510 0 1 {name=l1572 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -5490 0 1 {name=l1573 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -5470 0 1 {name=l1574 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -5450 0 1 {name=l1575 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -5430 0 1 {name=l1576 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -5410 0 1 {name=l1577 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -5390 0 1 {name=l1578 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -5370 0 1 {name=l1579 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -5350 0 1 {name=l1580 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -5330 0 1 {name=l1581 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -4650 2 0 {name=r647}
C {devices/bus_connect_nolab.sym} 3750 -4670 2 0 {name=r648}
C {devices/bus_connect_nolab.sym} 3750 -4690 2 0 {name=r649}
C {devices/bus_connect_nolab.sym} 3750 -4710 2 0 {name=r650}
C {devices/bus_connect_nolab.sym} 3750 -4730 2 0 {name=r651}
C {devices/bus_connect_nolab.sym} 3750 -4750 2 0 {name=r652}
C {devices/bus_connect_nolab.sym} 3750 -4770 2 0 {name=r653}
C {devices/bus_connect_nolab.sym} 3750 -4790 2 0 {name=r654}
C {devices/bus_connect_nolab.sym} 3750 -4810 2 0 {name=r655}
C {devices/bus_connect_nolab.sym} 3750 -4830 2 0 {name=r656}
C {devices/bus_connect_nolab.sym} 3750 -4850 2 0 {name=r657}
C {devices/bus_connect_nolab.sym} 3750 -4870 2 0 {name=r658}
C {devices/bus_connect_nolab.sym} 3750 -4890 2 0 {name=r659}
C {devices/bus_connect_nolab.sym} 3750 -4910 2 0 {name=r660}
C {devices/bus_connect_nolab.sym} 3750 -4930 2 0 {name=r661}
C {devices/bus_connect_nolab.sym} 3750 -4950 2 0 {name=r662}
C {devices/lab_pin.sym} 3740 -4610 3 0 {name=l1582 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -4650 2 1 {name=r663}
C {devices/bus_connect_nolab.sym} 4170 -4670 2 1 {name=r664}
C {devices/bus_connect_nolab.sym} 4170 -4690 2 1 {name=r665}
C {devices/bus_connect_nolab.sym} 4170 -4710 2 1 {name=r666}
C {devices/bus_connect_nolab.sym} 4170 -4730 2 1 {name=r667}
C {devices/bus_connect_nolab.sym} 4170 -4750 2 1 {name=r668}
C {devices/bus_connect_nolab.sym} 4170 -4770 2 1 {name=r669}
C {devices/bus_connect_nolab.sym} 4170 -4790 2 1 {name=r670}
C {devices/bus_connect_nolab.sym} 4170 -4810 2 1 {name=r671}
C {devices/bus_connect_nolab.sym} 4170 -4830 2 1 {name=r672}
C {devices/bus_connect_nolab.sym} 4170 -4850 2 1 {name=r673}
C {devices/bus_connect_nolab.sym} 4170 -4870 2 1 {name=r674}
C {devices/bus_connect_nolab.sym} 4170 -4890 2 1 {name=r675}
C {devices/bus_connect_nolab.sym} 4170 -4910 2 1 {name=r676}
C {devices/bus_connect_nolab.sym} 4170 -4930 2 1 {name=r677}
C {devices/bus_connect_nolab.sym} 4170 -4950 2 1 {name=r678}
C {devices/lab_pin.sym} 4180 -4610 1 1 {name=l1583 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -4670 0 0 {name=l1584 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -4690 0 0 {name=l1585 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -4710 0 0 {name=l1586 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -4730 0 0 {name=l1587 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -4750 0 0 {name=l1588 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -4770 0 0 {name=l1589 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -4790 0 0 {name=l1590 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3790 -4810 0 0 {name=l1591 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -4830 0 0 {name=l1592 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -4870 0 0 {name=l1593 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -4850 0 0 {name=l1594 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -4890 0 0 {name=l1595 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -4910 0 0 {name=l1596 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -4930 0 0 {name=l1597 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -4950 0 0 {name=l1598 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -4650 0 0 {name=l1599 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -4670 0 1 {name=l1600 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -4690 0 1 {name=l1601 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -4710 0 1 {name=l1602 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -4730 0 1 {name=l1603 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -4750 0 1 {name=l1604 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -4770 0 1 {name=l1605 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -4790 0 1 {name=l1606 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -4810 0 1 {name=l1607 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -4830 0 1 {name=l1608 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -4870 0 1 {name=l1609 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -4850 0 1 {name=l1610 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -4890 0 1 {name=l1611 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -4910 0 1 {name=l1612 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -4930 0 1 {name=l1613 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -4950 0 1 {name=l1614 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -4650 0 1 {name=l1615 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -5820 2 1 {name=l1616 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -5840 0 0 {name=l1617 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -5940 0 0 {name=l1618 lab=row2_sel}
C {devices/lab_pin.sym} 2340 -5920 0 0 {name=l1619 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -5860 0 0 {name=l1620 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -5900 0 0 {name=l1621 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -5880 0 0 {name=l1622 lab=WR}
C {devices/lab_pin.sym} 2340 -5800 2 1 {name=l1623 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -5740 0 0 {name=l1624 lab=Vref}
C {devices/lab_pin.sym} 2340 -5700 0 0 {name=l1625 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -5720 0 0 {name=l1626 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -5760 2 1 {name=l1627 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -5780 2 1 {name=l1628 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -5810 2 1 {name=l1629 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -5830 0 0 {name=l1630 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -5930 0 0 {name=l1631 lab=row2_sel}
C {devices/lab_pin.sym} 3040 -5910 0 0 {name=l1632 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -5850 0 0 {name=l1633 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -5890 0 0 {name=l1634 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -5870 0 0 {name=l1635 lab=WR}
C {devices/lab_pin.sym} 3040 -5790 2 1 {name=l1636 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -5730 0 0 {name=l1637 lab=Vref}
C {devices/lab_pin.sym} 3040 -5690 0 0 {name=l1638 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -5710 0 0 {name=l1639 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -5750 2 1 {name=l1640 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -5770 2 1 {name=l1641 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -5810 2 1 {name=l1642 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -5830 0 0 {name=l1643 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -5930 0 0 {name=l1644 lab=row2_sel}
C {devices/lab_pin.sym} 3750 -5910 0 0 {name=l1645 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -5850 0 0 {name=l1646 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -5890 0 0 {name=l1647 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -5870 0 0 {name=l1648 lab=WR}
C {devices/lab_pin.sym} 3750 -5790 2 1 {name=l1649 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -5730 0 0 {name=l1650 lab=Vref}
C {devices/lab_pin.sym} 3750 -5690 0 0 {name=l1651 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -5710 0 0 {name=l1652 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -5750 2 1 {name=l1653 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -5770 2 1 {name=l1654 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -3820 2 1 {name=l1655 lab=Vrminus}
C {devices/lab_pin.sym} 190 -3840 0 0 {name=l1656 lab=SAMPLE}
C {devices/lab_pin.sym} 190 -3860 0 0 {name=l1657 lab=Vgpr}
C {devices/lab_pin.sym} 190 -3900 0 0 {name=l1658 lab=Vgnr}
C {devices/lab_pin.sym} 190 -3880 0 0 {name=l1659 lab=WR}
C {devices/lab_pin.sym} 190 -3800 2 1 {name=l1660 lab=Vrplus}
C {devices/lab_pin.sym} 190 -3740 0 0 {name=l1661 lab=Vref}
C {devices/lab_pin.sym} 190 -3700 0 0 {name=l1662 lab=Vcplus}
C {devices/lab_pin.sym} 190 -3720 0 0 {name=l1663 lab=Vcminus}
C {devices/lab_pin.sym} 190 -3760 2 1 {name=l1664 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 190 -3780 2 1 {name=l1665 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 610 -3900 2 0 {name=l1666 lab=vdda1}
C {devices/lab_pin.sym} 610 -3920 2 0 {name=l1668 lab=vccd1}
C {devices/lab_pin.sym} 190 -5820 2 1 {name=l1669 lab=Vrminus}
C {devices/lab_pin.sym} 190 -5840 0 0 {name=l1670 lab=SAMPLE}
C {devices/lab_pin.sym} 190 -5860 0 0 {name=l1671 lab=Vgpr}
C {devices/lab_pin.sym} 190 -5900 0 0 {name=l1672 lab=Vgnr}
C {devices/lab_pin.sym} 190 -5880 0 0 {name=l1673 lab=WR}
C {devices/lab_pin.sym} 190 -5800 2 1 {name=l1674 lab=Vrplus}
C {devices/lab_pin.sym} 190 -5740 0 0 {name=l1675 lab=Vref}
C {devices/lab_pin.sym} 190 -5700 0 0 {name=l1676 lab=Vcplus}
C {devices/lab_pin.sym} 190 -5720 0 0 {name=l1677 lab=Vcminus}
C {devices/lab_pin.sym} 190 -5760 2 1 {name=l1678 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 190 -5780 2 1 {name=l1679 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 610 -5900 2 0 {name=l1680 lab=vdda1}
C {devices/lab_pin.sym} 610 -5920 2 0 {name=l1682 lab=vccd1}
C {devices/lab_pin.sym} 610 -5940 2 0 {name=l1689 lab=latch_high0}
C {devices/lab_pin.sym} 2030 -5930 2 0 {name=l1690 lab=latch_high2}
C {devices/lab_pin.sym} 2760 -5940 2 0 {name=l1691 lab=latch_high3}
C {devices/lab_pin.sym} 3460 -5930 2 0 {name=l1692 lab=latch_high4}
C {devices/lab_pin.sym} 4170 -5930 2 0 {name=l1693 lab=latch_high5}
C {devices/lab_pin.sym} 1330 -5940 2 0 {name=l1694 lab=latch_high1}
C {devices/lab_pin.sym} 190 -7960 0 0 {name=l1695 lab=row3_sel}
C {devices/lab_pin.sym} 190 -7940 0 0 {name=l1696 lab=col0_sel}
C {devices/lab_pin.sym} 910 -7840 2 1 {name=l1697 lab=Vrminus}
C {devices/lab_pin.sym} 910 -7860 0 0 {name=l1698 lab=SAMPLE}
C {devices/lab_pin.sym} 2760 -7920 2 0 {name=l1699 lab=vdda1}
C {devices/lab_pin.sym} 2760 -7940 2 0 {name=l1701 lab=vccd1}
C {devices/lab_pin.sym} 3460 -7910 2 0 {name=l1702 lab=vdda1}
C {devices/lab_pin.sym} 3460 -7930 2 0 {name=l1704 lab=vccd1}
C {devices/lab_pin.sym} 4170 -7910 2 0 {name=l1705 lab=vdda1}
C {devices/lab_pin.sym} 4170 -7930 2 0 {name=l1707 lab=vccd1}
C {devices/lab_wire.sym} 130 -7320 0 0 {name=l1708 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -7300 0 0 {name=l1709 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -7280 0 0 {name=l1710 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -7260 0 0 {name=l1711 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -7240 0 0 {name=l1712 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -7220 0 0 {name=l1713 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -7200 0 0 {name=l1714 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -7180 0 0 {name=l1715 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -7160 0 0 {name=l1716 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -7140 0 0 {name=l1717 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -7120 0 0 {name=l1718 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -7100 0 0 {name=l1719 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -7080 0 0 {name=l1720 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -7060 0 0 {name=l1721 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -7040 0 0 {name=l1722 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -7020 0 0 {name=l1723 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -6980 3 0 {name=l1724 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -7020 2 0 {name=r1447}
C {devices/bus_connect_nolab.sym} 70 -7040 2 0 {name=r1448}
C {devices/bus_connect_nolab.sym} 70 -7060 2 0 {name=r1449}
C {devices/bus_connect_nolab.sym} 70 -7080 2 0 {name=r1450}
C {devices/bus_connect_nolab.sym} 70 -7100 2 0 {name=r1451}
C {devices/bus_connect_nolab.sym} 70 -7120 2 0 {name=r1452}
C {devices/bus_connect_nolab.sym} 70 -7140 2 0 {name=r1453}
C {devices/bus_connect_nolab.sym} 70 -7160 2 0 {name=r1454}
C {devices/bus_connect_nolab.sym} 70 -7180 2 0 {name=r1455}
C {devices/bus_connect_nolab.sym} 70 -7200 2 0 {name=r1456}
C {devices/bus_connect_nolab.sym} 70 -7220 2 0 {name=r1457}
C {devices/bus_connect_nolab.sym} 70 -7240 2 0 {name=r1458}
C {devices/bus_connect_nolab.sym} 70 -7260 2 0 {name=r1459}
C {devices/bus_connect_nolab.sym} 70 -7280 2 0 {name=r1460}
C {devices/bus_connect_nolab.sym} 70 -7300 2 0 {name=r1461}
C {devices/bus_connect_nolab.sym} 70 -7320 2 0 {name=r1462}
C {devices/lab_wire.sym} 850 -7320 0 0 {name=l1725 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -7300 0 0 {name=l1726 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -7280 0 0 {name=l1727 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -7260 0 0 {name=l1728 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -7240 0 0 {name=l1729 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -7220 0 0 {name=l1730 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -7200 0 0 {name=l1731 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -7180 0 0 {name=l1732 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -7160 0 0 {name=l1733 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -7140 0 0 {name=l1734 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -7120 0 0 {name=l1735 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -7100 0 0 {name=l1736 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -7080 0 0 {name=l1737 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -7060 0 0 {name=l1738 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -7040 0 0 {name=l1739 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -6980 3 0 {name=l1740 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -7020 2 0 {name=r1463}
C {devices/bus_connect_nolab.sym} 790 -7040 2 0 {name=r1464}
C {devices/bus_connect_nolab.sym} 790 -7060 2 0 {name=r1465}
C {devices/bus_connect_nolab.sym} 790 -7080 2 0 {name=r1466}
C {devices/bus_connect_nolab.sym} 790 -7100 2 0 {name=r1467}
C {devices/bus_connect_nolab.sym} 790 -7120 2 0 {name=r1468}
C {devices/bus_connect_nolab.sym} 790 -7140 2 0 {name=r1469}
C {devices/bus_connect_nolab.sym} 790 -7160 2 0 {name=r1470}
C {devices/bus_connect_nolab.sym} 790 -7180 2 0 {name=r1471}
C {devices/bus_connect_nolab.sym} 790 -7200 2 0 {name=r1472}
C {devices/bus_connect_nolab.sym} 790 -7220 2 0 {name=r1473}
C {devices/bus_connect_nolab.sym} 790 -7240 2 0 {name=r1474}
C {devices/bus_connect_nolab.sym} 790 -7260 2 0 {name=r1475}
C {devices/bus_connect_nolab.sym} 790 -7280 2 0 {name=r1476}
C {devices/bus_connect_nolab.sym} 790 -7300 2 0 {name=r1477}
C {devices/bus_connect_nolab.sym} 790 -7320 2 0 {name=r1478}
C {devices/lab_wire.sym} 850 -7020 0 0 {name=l1741 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -7310 0 0 {name=l1742 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -7290 0 0 {name=l1743 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -7270 0 0 {name=l1744 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -7250 0 0 {name=l1745 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -7230 0 0 {name=l1746 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -7210 0 0 {name=l1747 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -7190 0 0 {name=l1748 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -7170 0 0 {name=l1749 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -7150 0 0 {name=l1750 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -7130 0 0 {name=l1751 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -7110 0 0 {name=l1752 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -7090 0 0 {name=l1753 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -7070 0 0 {name=l1754 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -7050 0 0 {name=l1755 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -7030 0 0 {name=l1756 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -6970 0 0 {name=l1757 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -7010 2 0 {name=r1479}
C {devices/bus_connect_nolab.sym} 1490 -7030 2 0 {name=r1480}
C {devices/bus_connect_nolab.sym} 1490 -7050 2 0 {name=r1481}
C {devices/bus_connect_nolab.sym} 1490 -7070 2 0 {name=r1482}
C {devices/bus_connect_nolab.sym} 1490 -7090 2 0 {name=r1483}
C {devices/bus_connect_nolab.sym} 1490 -7110 2 0 {name=r1484}
C {devices/bus_connect_nolab.sym} 1490 -7130 2 0 {name=r1485}
C {devices/bus_connect_nolab.sym} 1490 -7150 2 0 {name=r1486}
C {devices/bus_connect_nolab.sym} 1490 -7170 2 0 {name=r1487}
C {devices/bus_connect_nolab.sym} 1490 -7190 2 0 {name=r1488}
C {devices/bus_connect_nolab.sym} 1490 -7210 2 0 {name=r1489}
C {devices/bus_connect_nolab.sym} 1490 -7230 2 0 {name=r1490}
C {devices/bus_connect_nolab.sym} 1490 -7250 2 0 {name=r1491}
C {devices/bus_connect_nolab.sym} 1490 -7270 2 0 {name=r1492}
C {devices/bus_connect_nolab.sym} 1490 -7290 2 0 {name=r1493}
C {devices/bus_connect_nolab.sym} 1490 -7310 2 0 {name=r1494}
C {devices/lab_wire.sym} 1550 -7010 0 0 {name=l1758 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -7320 0 0 {name=l1759 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -7300 0 0 {name=l1760 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -7280 0 0 {name=l1761 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -7260 0 0 {name=l1762 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -7240 0 0 {name=l1763 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -7220 0 0 {name=l1764 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -7200 0 0 {name=l1765 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -7180 0 0 {name=l1766 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -7160 0 0 {name=l1767 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -7140 0 0 {name=l1768 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -7120 0 0 {name=l1769 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -7100 0 0 {name=l1770 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -7080 0 0 {name=l1771 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -7060 0 0 {name=l1772 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -7040 0 0 {name=l1773 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -6980 0 0 {name=l1774 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -7020 2 0 {name=r1495}
C {devices/bus_connect_nolab.sym} 2220 -7040 2 0 {name=r1496}
C {devices/bus_connect_nolab.sym} 2220 -7060 2 0 {name=r1497}
C {devices/bus_connect_nolab.sym} 2220 -7080 2 0 {name=r1498}
C {devices/bus_connect_nolab.sym} 2220 -7100 2 0 {name=r1499}
C {devices/bus_connect_nolab.sym} 2220 -7120 2 0 {name=r1500}
C {devices/bus_connect_nolab.sym} 2220 -7140 2 0 {name=r1501}
C {devices/bus_connect_nolab.sym} 2220 -7160 2 0 {name=r1502}
C {devices/bus_connect_nolab.sym} 2220 -7180 2 0 {name=r1503}
C {devices/bus_connect_nolab.sym} 2220 -7200 2 0 {name=r1504}
C {devices/bus_connect_nolab.sym} 2220 -7220 2 0 {name=r1505}
C {devices/bus_connect_nolab.sym} 2220 -7240 2 0 {name=r1506}
C {devices/bus_connect_nolab.sym} 2220 -7260 2 0 {name=r1507}
C {devices/bus_connect_nolab.sym} 2220 -7280 2 0 {name=r1508}
C {devices/bus_connect_nolab.sym} 2220 -7300 2 0 {name=r1509}
C {devices/bus_connect_nolab.sym} 2220 -7320 2 0 {name=r1510}
C {devices/lab_wire.sym} 2280 -7020 0 0 {name=l1775 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -7310 0 0 {name=l1776 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -7290 0 0 {name=l1777 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -7270 0 0 {name=l1778 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -7250 0 0 {name=l1779 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -7230 0 0 {name=l1780 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -7210 0 0 {name=l1781 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -7190 0 0 {name=l1782 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -7170 0 0 {name=l1783 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -7150 0 0 {name=l1784 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -7130 0 0 {name=l1785 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -7110 0 0 {name=l1786 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -7090 0 0 {name=l1787 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -7070 0 0 {name=l1788 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -7050 0 0 {name=l1789 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -7030 0 0 {name=l1790 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -6970 0 0 {name=l1791 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -7010 2 0 {name=r1511}
C {devices/bus_connect_nolab.sym} 2920 -7030 2 0 {name=r1512}
C {devices/bus_connect_nolab.sym} 2920 -7050 2 0 {name=r1513}
C {devices/bus_connect_nolab.sym} 2920 -7070 2 0 {name=r1514}
C {devices/bus_connect_nolab.sym} 2920 -7090 2 0 {name=r1515}
C {devices/bus_connect_nolab.sym} 2920 -7110 2 0 {name=r1516}
C {devices/bus_connect_nolab.sym} 2920 -7130 2 0 {name=r1517}
C {devices/bus_connect_nolab.sym} 2920 -7150 2 0 {name=r1518}
C {devices/bus_connect_nolab.sym} 2920 -7170 2 0 {name=r1519}
C {devices/bus_connect_nolab.sym} 2920 -7190 2 0 {name=r1520}
C {devices/bus_connect_nolab.sym} 2920 -7210 2 0 {name=r1521}
C {devices/bus_connect_nolab.sym} 2920 -7230 2 0 {name=r1522}
C {devices/bus_connect_nolab.sym} 2920 -7250 2 0 {name=r1523}
C {devices/bus_connect_nolab.sym} 2920 -7270 2 0 {name=r1524}
C {devices/bus_connect_nolab.sym} 2920 -7290 2 0 {name=r1525}
C {devices/bus_connect_nolab.sym} 2920 -7310 2 0 {name=r1526}
C {devices/lab_wire.sym} 2980 -7010 0 0 {name=l1792 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -7310 0 0 {name=l1793 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -7290 0 0 {name=l1794 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -7270 0 0 {name=l1795 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -7250 0 0 {name=l1796 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -7230 0 0 {name=l1797 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -7210 0 0 {name=l1798 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -7190 0 0 {name=l1799 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -7170 0 0 {name=l1800 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -7150 0 0 {name=l1801 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -7130 0 0 {name=l1802 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -7110 0 0 {name=l1803 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -7090 0 0 {name=l1804 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -7070 0 0 {name=l1805 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -7050 0 0 {name=l1806 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -7030 0 0 {name=l1807 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -6970 0 0 {name=l1808 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -7010 2 0 {name=r1527}
C {devices/bus_connect_nolab.sym} 3630 -7030 2 0 {name=r1528}
C {devices/bus_connect_nolab.sym} 3630 -7050 2 0 {name=r1529}
C {devices/bus_connect_nolab.sym} 3630 -7070 2 0 {name=r1530}
C {devices/bus_connect_nolab.sym} 3630 -7090 2 0 {name=r1531}
C {devices/bus_connect_nolab.sym} 3630 -7110 2 0 {name=r1532}
C {devices/bus_connect_nolab.sym} 3630 -7130 2 0 {name=r1533}
C {devices/bus_connect_nolab.sym} 3630 -7150 2 0 {name=r1534}
C {devices/bus_connect_nolab.sym} 3630 -7170 2 0 {name=r1535}
C {devices/bus_connect_nolab.sym} 3630 -7190 2 0 {name=r1536}
C {devices/bus_connect_nolab.sym} 3630 -7210 2 0 {name=r1537}
C {devices/bus_connect_nolab.sym} 3630 -7230 2 0 {name=r1538}
C {devices/bus_connect_nolab.sym} 3630 -7250 2 0 {name=r1539}
C {devices/bus_connect_nolab.sym} 3630 -7270 2 0 {name=r1540}
C {devices/bus_connect_nolab.sym} 3630 -7290 2 0 {name=r1541}
C {devices/bus_connect_nolab.sym} 3630 -7310 2 0 {name=r1542}
C {devices/lab_wire.sym} 3690 -7010 0 0 {name=l1809 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} 40 -7360 2 0 {name=r1543}
C {devices/bus_connect_nolab.sym} 40 -7380 2 0 {name=r1544}
C {devices/bus_connect_nolab.sym} 40 -7400 2 0 {name=r1545}
C {devices/bus_connect_nolab.sym} 40 -7420 2 0 {name=r1546}
C {devices/bus_connect_nolab.sym} 40 -7440 2 0 {name=r1547}
C {devices/bus_connect_nolab.sym} 40 -7460 2 0 {name=r1548}
C {devices/bus_connect_nolab.sym} 40 -7480 2 0 {name=r1549}
C {devices/bus_connect_nolab.sym} 40 -7500 2 0 {name=r1550}
C {devices/bus_connect_nolab.sym} 40 -7520 2 0 {name=r1551}
C {devices/bus_connect_nolab.sym} 40 -7540 2 0 {name=r1552}
C {devices/bus_connect_nolab.sym} 40 -7580 2 0 {name=r1553}
C {devices/bus_connect_nolab.sym} 40 -7560 2 0 {name=r1554}
C {devices/bus_connect_nolab.sym} 40 -7620 2 0 {name=r1555}
C {devices/bus_connect_nolab.sym} 40 -7600 2 0 {name=r1556}
C {devices/bus_connect_nolab.sym} 40 -7660 2 0 {name=r1557}
C {devices/bus_connect_nolab.sym} 40 -7640 2 0 {name=r1558}
C {devices/lab_wire.sym} 90 -7360 0 0 {name=l1810 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -7380 0 0 {name=l1811 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -7400 0 0 {name=l1812 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -7400 0 0 {name=l1813 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -7420 0 0 {name=l1814 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -7440 0 0 {name=l1815 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -7460 0 0 {name=l1816 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -7480 0 0 {name=l1817 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -7500 0 0 {name=l1818 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -7520 0 0 {name=l1819 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -7540 0 0 {name=l1820 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -7580 0 0 {name=l1821 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -7560 0 0 {name=l1822 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -7600 0 0 {name=l1823 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -7620 0 0 {name=l1824 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -7640 0 0 {name=l1825 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -7660 0 0 {name=l1826 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -7310 3 0 {name=l1827 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -7360 2 1 {name=r1559}
C {devices/bus_connect_nolab.sym} 660 -7380 2 1 {name=r1560}
C {devices/bus_connect_nolab.sym} 660 -7400 2 1 {name=r1561}
C {devices/bus_connect_nolab.sym} 660 -7420 2 1 {name=r1562}
C {devices/bus_connect_nolab.sym} 660 -7440 2 1 {name=r1563}
C {devices/bus_connect_nolab.sym} 660 -7460 2 1 {name=r1564}
C {devices/bus_connect_nolab.sym} 660 -7480 2 1 {name=r1565}
C {devices/bus_connect_nolab.sym} 660 -7500 2 1 {name=r1566}
C {devices/bus_connect_nolab.sym} 660 -7520 2 1 {name=r1567}
C {devices/bus_connect_nolab.sym} 660 -7540 2 1 {name=r1568}
C {devices/bus_connect_nolab.sym} 660 -7560 2 1 {name=r1569}
C {devices/bus_connect_nolab.sym} 660 -7580 2 1 {name=r1570}
C {devices/bus_connect_nolab.sym} 660 -7600 2 1 {name=r1571}
C {devices/bus_connect_nolab.sym} 660 -7620 2 1 {name=r1572}
C {devices/bus_connect_nolab.sym} 660 -7640 2 1 {name=r1573}
C {devices/bus_connect_nolab.sym} 660 -7660 2 1 {name=r1574}
C {devices/lab_pin.sym} 670 -7310 3 0 {name=l1828 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -7660 0 1 {name=l1829 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -7640 0 1 {name=l1830 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -7620 0 1 {name=l1831 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -7600 0 1 {name=l1832 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -7580 0 1 {name=l1833 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -7560 0 1 {name=l1834 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -7540 0 1 {name=l1835 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -7520 0 1 {name=l1836 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -7500 0 1 {name=l1837 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -7480 0 1 {name=l1838 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -7460 0 1 {name=l1839 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -7440 0 1 {name=l1840 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -7420 0 1 {name=l1841 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -7400 0 1 {name=l1842 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -7380 0 1 {name=l1843 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -7360 0 1 {name=l1844 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 190 -6680 2 0 {name=r1575}
C {devices/bus_connect_nolab.sym} 190 -6700 2 0 {name=r1576}
C {devices/bus_connect_nolab.sym} 190 -6720 2 0 {name=r1577}
C {devices/bus_connect_nolab.sym} 190 -6740 2 0 {name=r1578}
C {devices/bus_connect_nolab.sym} 190 -6760 2 0 {name=r1579}
C {devices/bus_connect_nolab.sym} 190 -6780 2 0 {name=r1580}
C {devices/bus_connect_nolab.sym} 190 -6800 2 0 {name=r1581}
C {devices/bus_connect_nolab.sym} 190 -6820 2 0 {name=r1582}
C {devices/bus_connect_nolab.sym} 190 -6840 2 0 {name=r1583}
C {devices/bus_connect_nolab.sym} 190 -6860 2 0 {name=r1584}
C {devices/bus_connect_nolab.sym} 190 -6880 2 0 {name=r1585}
C {devices/bus_connect_nolab.sym} 190 -6900 2 0 {name=r1586}
C {devices/bus_connect_nolab.sym} 190 -6920 2 0 {name=r1587}
C {devices/bus_connect_nolab.sym} 190 -6940 2 0 {name=r1588}
C {devices/bus_connect_nolab.sym} 190 -6960 2 0 {name=r1589}
C {devices/bus_connect_nolab.sym} 190 -6980 2 0 {name=r1590}
C {devices/lab_pin.sym} 180 -6640 3 0 {name=l1845 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -6680 2 1 {name=r1591}
C {devices/bus_connect_nolab.sym} 610 -6700 2 1 {name=r1592}
C {devices/bus_connect_nolab.sym} 610 -6720 2 1 {name=r1593}
C {devices/bus_connect_nolab.sym} 610 -6740 2 1 {name=r1594}
C {devices/bus_connect_nolab.sym} 610 -6760 2 1 {name=r1595}
C {devices/bus_connect_nolab.sym} 610 -6780 2 1 {name=r1596}
C {devices/bus_connect_nolab.sym} 610 -6800 2 1 {name=r1597}
C {devices/bus_connect_nolab.sym} 610 -6820 2 1 {name=r1598}
C {devices/bus_connect_nolab.sym} 610 -6840 2 1 {name=r1599}
C {devices/bus_connect_nolab.sym} 610 -6860 2 1 {name=r1600}
C {devices/bus_connect_nolab.sym} 610 -6880 2 1 {name=r1601}
C {devices/bus_connect_nolab.sym} 610 -6900 2 1 {name=r1602}
C {devices/bus_connect_nolab.sym} 610 -6920 2 1 {name=r1603}
C {devices/bus_connect_nolab.sym} 610 -6940 2 1 {name=r1604}
C {devices/bus_connect_nolab.sym} 610 -6960 2 1 {name=r1605}
C {devices/bus_connect_nolab.sym} 610 -6980 2 1 {name=r1606}
C {devices/lab_pin.sym} 620 -6640 1 1 {name=l1846 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -6700 0 0 {name=l1847 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -6720 0 0 {name=l1848 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -6740 0 0 {name=l1849 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -6760 0 0 {name=l1850 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -6780 0 0 {name=l1851 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -6800 0 0 {name=l1852 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -6820 0 0 {name=l1853 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -6840 0 0 {name=l1854 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -6860 0 0 {name=l1855 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -6900 0 0 {name=l1856 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -6880 0 0 {name=l1857 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -6920 0 0 {name=l1858 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -6940 0 0 {name=l1859 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -6960 0 0 {name=l1860 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -6980 0 0 {name=l1861 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -6680 0 0 {name=l1862 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -6700 0 1 {name=l1863 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -6720 0 1 {name=l1864 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -6740 0 1 {name=l1865 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -6760 0 1 {name=l1866 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -6780 0 1 {name=l1867 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -6800 0 1 {name=l1868 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -6820 0 1 {name=l1869 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -6840 0 1 {name=l1870 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -6860 0 1 {name=l1871 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -6900 0 1 {name=l1872 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -6880 0 1 {name=l1873 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -6920 0 1 {name=l1874 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -6940 0 1 {name=l1875 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -6960 0 1 {name=l1876 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -6980 0 1 {name=l1877 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -6680 0 1 {name=l1878 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -7960 0 0 {name=l1879 lab=row3_sel}
C {devices/lab_pin.sym} 910 -7940 0 0 {name=l1880 lab=col1_sel}
C {devices/bus_connect_nolab.sym} 760 -7360 2 0 {name=r1607}
C {devices/bus_connect_nolab.sym} 760 -7380 2 0 {name=r1608}
C {devices/bus_connect_nolab.sym} 760 -7400 2 0 {name=r1609}
C {devices/bus_connect_nolab.sym} 760 -7420 2 0 {name=r1610}
C {devices/bus_connect_nolab.sym} 760 -7440 2 0 {name=r1611}
C {devices/bus_connect_nolab.sym} 760 -7460 2 0 {name=r1612}
C {devices/bus_connect_nolab.sym} 760 -7480 2 0 {name=r1613}
C {devices/bus_connect_nolab.sym} 760 -7500 2 0 {name=r1614}
C {devices/bus_connect_nolab.sym} 760 -7520 2 0 {name=r1615}
C {devices/bus_connect_nolab.sym} 760 -7540 2 0 {name=r1616}
C {devices/bus_connect_nolab.sym} 760 -7580 2 0 {name=r1617}
C {devices/bus_connect_nolab.sym} 760 -7560 2 0 {name=r1618}
C {devices/bus_connect_nolab.sym} 760 -7620 2 0 {name=r1619}
C {devices/bus_connect_nolab.sym} 760 -7600 2 0 {name=r1620}
C {devices/bus_connect_nolab.sym} 760 -7660 2 0 {name=r1621}
C {devices/bus_connect_nolab.sym} 760 -7640 2 0 {name=r1622}
C {devices/lab_wire.sym} 810 -7360 0 0 {name=l1881 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -7380 0 0 {name=l1882 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -7400 0 0 {name=l1883 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -7400 0 0 {name=l1884 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -7420 0 0 {name=l1885 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -7440 0 0 {name=l1886 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -7460 0 0 {name=l1887 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -7480 0 0 {name=l1888 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -7500 0 0 {name=l1889 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -7520 0 0 {name=l1890 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -7540 0 0 {name=l1891 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -7580 0 0 {name=l1892 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -7560 0 0 {name=l1893 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -7600 0 0 {name=l1894 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -7620 0 0 {name=l1895 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -7640 0 0 {name=l1896 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -7660 0 0 {name=l1897 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -7310 3 0 {name=l1898 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -7360 2 1 {name=r1623}
C {devices/bus_connect_nolab.sym} 1380 -7380 2 1 {name=r1624}
C {devices/bus_connect_nolab.sym} 1380 -7400 2 1 {name=r1625}
C {devices/bus_connect_nolab.sym} 1380 -7420 2 1 {name=r1626}
C {devices/bus_connect_nolab.sym} 1380 -7440 2 1 {name=r1627}
C {devices/bus_connect_nolab.sym} 1380 -7460 2 1 {name=r1628}
C {devices/bus_connect_nolab.sym} 1380 -7480 2 1 {name=r1629}
C {devices/bus_connect_nolab.sym} 1380 -7500 2 1 {name=r1630}
C {devices/bus_connect_nolab.sym} 1380 -7520 2 1 {name=r1631}
C {devices/bus_connect_nolab.sym} 1380 -7540 2 1 {name=r1632}
C {devices/bus_connect_nolab.sym} 1380 -7560 2 1 {name=r1633}
C {devices/bus_connect_nolab.sym} 1380 -7580 2 1 {name=r1634}
C {devices/bus_connect_nolab.sym} 1380 -7600 2 1 {name=r1635}
C {devices/bus_connect_nolab.sym} 1380 -7620 2 1 {name=r1636}
C {devices/bus_connect_nolab.sym} 1380 -7640 2 1 {name=r1637}
C {devices/bus_connect_nolab.sym} 1380 -7660 2 1 {name=r1638}
C {devices/lab_pin.sym} 1390 -7310 3 0 {name=l1899 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -7660 0 1 {name=l1900 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -7640 0 1 {name=l1901 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -7620 0 1 {name=l1902 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -7600 0 1 {name=l1903 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -7580 0 1 {name=l1904 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -7560 0 1 {name=l1905 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -7540 0 1 {name=l1906 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -7520 0 1 {name=l1907 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -7500 0 1 {name=l1908 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -7480 0 1 {name=l1909 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -7460 0 1 {name=l1910 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -7440 0 1 {name=l1911 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -7420 0 1 {name=l1912 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -7400 0 1 {name=l1913 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -7380 0 1 {name=l1914 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -7360 0 1 {name=l1915 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -7880 0 0 {name=l1916 lab=Vgpr}
C {devices/lab_pin.sym} 910 -7920 0 0 {name=l1917 lab=Vgnr}
C {devices/lab_pin.sym} 910 -7900 0 0 {name=l1918 lab=WR}
C {devices/lab_pin.sym} 910 -7820 2 1 {name=l1919 lab=Vrplus}
C {devices/lab_pin.sym} 910 -7760 0 0 {name=l1920 lab=Vref}
C {devices/lab_pin.sym} 910 -7720 0 0 {name=l1921 lab=Vcplus}
C {devices/lab_pin.sym} 910 -7740 0 0 {name=l1922 lab=Vcminus}
C {devices/lab_pin.sym} 910 -7780 2 1 {name=l1923 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -7800 2 1 {name=l1924 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -7920 2 0 {name=l1925 lab=vdda1}
C {devices/lab_pin.sym} 1330 -7940 2 0 {name=l1927 lab=vccd1}
C {devices/lab_pin.sym} 1610 -7830 2 1 {name=l1928 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -7850 0 0 {name=l1929 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -7950 0 0 {name=l1930 lab=row3_sel}
C {devices/lab_pin.sym} 1610 -7930 0 0 {name=l1931 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -7870 0 0 {name=l1932 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -7910 0 0 {name=l1933 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -7890 0 0 {name=l1934 lab=WR}
C {devices/lab_pin.sym} 1610 -7810 2 1 {name=l1935 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -7750 0 0 {name=l1936 lab=Vref}
C {devices/lab_pin.sym} 1610 -7710 0 0 {name=l1937 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -7730 0 0 {name=l1938 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -7770 2 1 {name=l1939 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -7790 2 1 {name=l1940 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -7910 2 0 {name=l1941 lab=vdda1}
C {devices/lab_pin.sym} 2030 -7930 2 0 {name=l1943 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -7350 2 0 {name=r1639}
C {devices/bus_connect_nolab.sym} 1460 -7370 2 0 {name=r1640}
C {devices/bus_connect_nolab.sym} 1460 -7390 2 0 {name=r1641}
C {devices/bus_connect_nolab.sym} 1460 -7410 2 0 {name=r1642}
C {devices/bus_connect_nolab.sym} 1460 -7430 2 0 {name=r1643}
C {devices/bus_connect_nolab.sym} 1460 -7450 2 0 {name=r1644}
C {devices/bus_connect_nolab.sym} 1460 -7470 2 0 {name=r1645}
C {devices/bus_connect_nolab.sym} 1460 -7490 2 0 {name=r1646}
C {devices/bus_connect_nolab.sym} 1460 -7510 2 0 {name=r1647}
C {devices/bus_connect_nolab.sym} 1460 -7530 2 0 {name=r1648}
C {devices/bus_connect_nolab.sym} 1460 -7570 2 0 {name=r1649}
C {devices/bus_connect_nolab.sym} 1460 -7550 2 0 {name=r1650}
C {devices/bus_connect_nolab.sym} 1460 -7610 2 0 {name=r1651}
C {devices/bus_connect_nolab.sym} 1460 -7590 2 0 {name=r1652}
C {devices/bus_connect_nolab.sym} 1460 -7650 2 0 {name=r1653}
C {devices/bus_connect_nolab.sym} 1460 -7630 2 0 {name=r1654}
C {devices/lab_wire.sym} 1510 -7350 0 0 {name=l1944 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -7370 0 0 {name=l1945 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -7390 0 0 {name=l1946 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -7390 0 0 {name=l1947 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -7410 0 0 {name=l1948 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -7430 0 0 {name=l1949 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -7450 0 0 {name=l1950 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -7470 0 0 {name=l1951 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -7490 0 0 {name=l1952 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -7510 0 0 {name=l1953 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -7530 0 0 {name=l1954 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -7570 0 0 {name=l1955 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -7550 0 0 {name=l1956 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -7590 0 0 {name=l1957 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -7610 0 0 {name=l1958 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -7630 0 0 {name=l1959 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -7650 0 0 {name=l1960 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -7300 3 0 {name=l1961 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -7350 2 1 {name=r1655}
C {devices/bus_connect_nolab.sym} 2080 -7370 2 1 {name=r1656}
C {devices/bus_connect_nolab.sym} 2080 -7390 2 1 {name=r1657}
C {devices/bus_connect_nolab.sym} 2080 -7410 2 1 {name=r1658}
C {devices/bus_connect_nolab.sym} 2080 -7430 2 1 {name=r1659}
C {devices/bus_connect_nolab.sym} 2080 -7450 2 1 {name=r1660}
C {devices/bus_connect_nolab.sym} 2080 -7470 2 1 {name=r1661}
C {devices/bus_connect_nolab.sym} 2080 -7490 2 1 {name=r1662}
C {devices/bus_connect_nolab.sym} 2080 -7510 2 1 {name=r1663}
C {devices/bus_connect_nolab.sym} 2080 -7530 2 1 {name=r1664}
C {devices/bus_connect_nolab.sym} 2080 -7550 2 1 {name=r1665}
C {devices/bus_connect_nolab.sym} 2080 -7570 2 1 {name=r1666}
C {devices/bus_connect_nolab.sym} 2080 -7590 2 1 {name=r1667}
C {devices/bus_connect_nolab.sym} 2080 -7610 2 1 {name=r1668}
C {devices/bus_connect_nolab.sym} 2080 -7630 2 1 {name=r1669}
C {devices/bus_connect_nolab.sym} 2080 -7650 2 1 {name=r1670}
C {devices/lab_pin.sym} 2090 -7300 3 0 {name=l1962 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -7650 0 1 {name=l1963 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -7630 0 1 {name=l1964 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -7610 0 1 {name=l1965 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -7590 0 1 {name=l1966 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -7570 0 1 {name=l1967 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -7550 0 1 {name=l1968 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -7530 0 1 {name=l1969 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -7510 0 1 {name=l1970 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -7490 0 1 {name=l1971 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -7470 0 1 {name=l1972 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -7450 0 1 {name=l1973 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -7430 0 1 {name=l1974 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -7410 0 1 {name=l1975 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -7390 0 1 {name=l1976 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -7370 0 1 {name=l1977 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -7350 0 1 {name=l1978 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -6680 2 0 {name=r1671}
C {devices/bus_connect_nolab.sym} 910 -6700 2 0 {name=r1672}
C {devices/bus_connect_nolab.sym} 910 -6720 2 0 {name=r1673}
C {devices/bus_connect_nolab.sym} 910 -6740 2 0 {name=r1674}
C {devices/bus_connect_nolab.sym} 910 -6760 2 0 {name=r1675}
C {devices/bus_connect_nolab.sym} 910 -6780 2 0 {name=r1676}
C {devices/bus_connect_nolab.sym} 910 -6800 2 0 {name=r1677}
C {devices/bus_connect_nolab.sym} 910 -6820 2 0 {name=r1678}
C {devices/bus_connect_nolab.sym} 910 -6840 2 0 {name=r1679}
C {devices/bus_connect_nolab.sym} 910 -6860 2 0 {name=r1680}
C {devices/bus_connect_nolab.sym} 910 -6880 2 0 {name=r1681}
C {devices/bus_connect_nolab.sym} 910 -6900 2 0 {name=r1682}
C {devices/bus_connect_nolab.sym} 910 -6920 2 0 {name=r1683}
C {devices/bus_connect_nolab.sym} 910 -6940 2 0 {name=r1684}
C {devices/bus_connect_nolab.sym} 910 -6960 2 0 {name=r1685}
C {devices/bus_connect_nolab.sym} 910 -6980 2 0 {name=r1686}
C {devices/lab_pin.sym} 900 -6640 3 0 {name=l1979 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -6680 2 1 {name=r1687}
C {devices/bus_connect_nolab.sym} 1330 -6700 2 1 {name=r1688}
C {devices/bus_connect_nolab.sym} 1330 -6720 2 1 {name=r1689}
C {devices/bus_connect_nolab.sym} 1330 -6740 2 1 {name=r1690}
C {devices/bus_connect_nolab.sym} 1330 -6760 2 1 {name=r1691}
C {devices/bus_connect_nolab.sym} 1330 -6780 2 1 {name=r1692}
C {devices/bus_connect_nolab.sym} 1330 -6800 2 1 {name=r1693}
C {devices/bus_connect_nolab.sym} 1330 -6820 2 1 {name=r1694}
C {devices/bus_connect_nolab.sym} 1330 -6840 2 1 {name=r1695}
C {devices/bus_connect_nolab.sym} 1330 -6860 2 1 {name=r1696}
C {devices/bus_connect_nolab.sym} 1330 -6880 2 1 {name=r1697}
C {devices/bus_connect_nolab.sym} 1330 -6900 2 1 {name=r1698}
C {devices/bus_connect_nolab.sym} 1330 -6920 2 1 {name=r1699}
C {devices/bus_connect_nolab.sym} 1330 -6940 2 1 {name=r1700}
C {devices/bus_connect_nolab.sym} 1330 -6960 2 1 {name=r1701}
C {devices/bus_connect_nolab.sym} 1330 -6980 2 1 {name=r1702}
C {devices/lab_pin.sym} 1340 -6640 1 1 {name=l1980 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -6700 0 0 {name=l1981 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -6720 0 0 {name=l1982 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -6740 0 0 {name=l1983 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -6760 0 0 {name=l1984 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -6780 0 0 {name=l1985 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -6800 0 0 {name=l1986 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -6820 0 0 {name=l1987 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -6840 0 0 {name=l1988 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -6860 0 0 {name=l1989 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -6900 0 0 {name=l1990 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -6880 0 0 {name=l1991 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -6920 0 0 {name=l1992 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -6940 0 0 {name=l1993 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -6960 0 0 {name=l1994 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -6980 0 0 {name=l1995 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -6680 0 0 {name=l1996 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -6700 0 1 {name=l1997 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -6720 0 1 {name=l1998 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -6740 0 1 {name=l1999 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -6760 0 1 {name=l2000 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -6780 0 1 {name=l2001 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -6800 0 1 {name=l2002 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -6820 0 1 {name=l2003 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -6840 0 1 {name=l2004 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -6860 0 1 {name=l2005 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -6900 0 1 {name=l2006 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -6880 0 1 {name=l2007 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -6920 0 1 {name=l2008 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -6940 0 1 {name=l2009 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -6960 0 1 {name=l2010 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -6980 0 1 {name=l2011 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -6680 0 1 {name=l2012 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -6670 2 0 {name=r1703}
C {devices/bus_connect_nolab.sym} 1610 -6690 2 0 {name=r1704}
C {devices/bus_connect_nolab.sym} 1610 -6710 2 0 {name=r1705}
C {devices/bus_connect_nolab.sym} 1610 -6730 2 0 {name=r1706}
C {devices/bus_connect_nolab.sym} 1610 -6750 2 0 {name=r1707}
C {devices/bus_connect_nolab.sym} 1610 -6770 2 0 {name=r1708}
C {devices/bus_connect_nolab.sym} 1610 -6790 2 0 {name=r1709}
C {devices/bus_connect_nolab.sym} 1610 -6810 2 0 {name=r1710}
C {devices/bus_connect_nolab.sym} 1610 -6830 2 0 {name=r1711}
C {devices/bus_connect_nolab.sym} 1610 -6850 2 0 {name=r1712}
C {devices/bus_connect_nolab.sym} 1610 -6870 2 0 {name=r1713}
C {devices/bus_connect_nolab.sym} 1610 -6890 2 0 {name=r1714}
C {devices/bus_connect_nolab.sym} 1610 -6910 2 0 {name=r1715}
C {devices/bus_connect_nolab.sym} 1610 -6930 2 0 {name=r1716}
C {devices/bus_connect_nolab.sym} 1610 -6950 2 0 {name=r1717}
C {devices/bus_connect_nolab.sym} 1610 -6970 2 0 {name=r1718}
C {devices/lab_pin.sym} 1600 -6630 3 0 {name=l2013 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -6670 2 1 {name=r1719}
C {devices/bus_connect_nolab.sym} 2030 -6690 2 1 {name=r1720}
C {devices/bus_connect_nolab.sym} 2030 -6710 2 1 {name=r1721}
C {devices/bus_connect_nolab.sym} 2030 -6730 2 1 {name=r1722}
C {devices/bus_connect_nolab.sym} 2030 -6750 2 1 {name=r1723}
C {devices/bus_connect_nolab.sym} 2030 -6770 2 1 {name=r1724}
C {devices/bus_connect_nolab.sym} 2030 -6790 2 1 {name=r1725}
C {devices/bus_connect_nolab.sym} 2030 -6810 2 1 {name=r1726}
C {devices/bus_connect_nolab.sym} 2030 -6830 2 1 {name=r1727}
C {devices/bus_connect_nolab.sym} 2030 -6850 2 1 {name=r1728}
C {devices/bus_connect_nolab.sym} 2030 -6870 2 1 {name=r1729}
C {devices/bus_connect_nolab.sym} 2030 -6890 2 1 {name=r1730}
C {devices/bus_connect_nolab.sym} 2030 -6910 2 1 {name=r1731}
C {devices/bus_connect_nolab.sym} 2030 -6930 2 1 {name=r1732}
C {devices/bus_connect_nolab.sym} 2030 -6950 2 1 {name=r1733}
C {devices/bus_connect_nolab.sym} 2030 -6970 2 1 {name=r1734}
C {devices/lab_pin.sym} 2040 -6630 1 1 {name=l2014 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -6690 0 0 {name=l2015 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -6710 0 0 {name=l2016 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -6730 0 0 {name=l2017 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -6750 0 0 {name=l2018 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -6770 0 0 {name=l2019 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -6790 0 0 {name=l2020 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -6810 0 0 {name=l2021 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -6830 0 0 {name=l2022 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -6850 0 0 {name=l2023 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -6890 0 0 {name=l2024 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -6870 0 0 {name=l2025 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -6910 0 0 {name=l2026 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -6930 0 0 {name=l2027 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -6950 0 0 {name=l2028 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -6970 0 0 {name=l2029 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -6670 0 0 {name=l2030 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -6690 0 1 {name=l2031 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -6710 0 1 {name=l2032 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -6730 0 1 {name=l2033 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -6750 0 1 {name=l2034 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -6770 0 1 {name=l2035 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -6790 0 1 {name=l2036 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -6810 0 1 {name=l2037 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -6830 0 1 {name=l2038 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -6850 0 1 {name=l2039 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -6890 0 1 {name=l2040 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -6870 0 1 {name=l2041 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -6910 0 1 {name=l2042 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -6930 0 1 {name=l2043 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -6950 0 1 {name=l2044 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -6970 0 1 {name=l2045 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -6670 0 1 {name=l2046 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -7360 2 0 {name=r1735}
C {devices/bus_connect_nolab.sym} 2190 -7380 2 0 {name=r1736}
C {devices/bus_connect_nolab.sym} 2190 -7400 2 0 {name=r1737}
C {devices/bus_connect_nolab.sym} 2190 -7420 2 0 {name=r1738}
C {devices/bus_connect_nolab.sym} 2190 -7440 2 0 {name=r1739}
C {devices/bus_connect_nolab.sym} 2190 -7460 2 0 {name=r1740}
C {devices/bus_connect_nolab.sym} 2190 -7480 2 0 {name=r1741}
C {devices/bus_connect_nolab.sym} 2190 -7500 2 0 {name=r1742}
C {devices/bus_connect_nolab.sym} 2190 -7520 2 0 {name=r1743}
C {devices/bus_connect_nolab.sym} 2190 -7540 2 0 {name=r1744}
C {devices/bus_connect_nolab.sym} 2190 -7580 2 0 {name=r1745}
C {devices/bus_connect_nolab.sym} 2190 -7560 2 0 {name=r1746}
C {devices/bus_connect_nolab.sym} 2190 -7620 2 0 {name=r1747}
C {devices/bus_connect_nolab.sym} 2190 -7600 2 0 {name=r1748}
C {devices/bus_connect_nolab.sym} 2190 -7660 2 0 {name=r1749}
C {devices/bus_connect_nolab.sym} 2190 -7640 2 0 {name=r1750}
C {devices/lab_wire.sym} 2240 -7360 0 0 {name=l2047 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -7380 0 0 {name=l2048 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -7400 0 0 {name=l2049 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -7400 0 0 {name=l2050 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -7420 0 0 {name=l2051 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -7440 0 0 {name=l2052 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -7460 0 0 {name=l2053 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -7480 0 0 {name=l2054 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -7500 0 0 {name=l2055 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -7520 0 0 {name=l2056 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -7540 0 0 {name=l2057 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -7580 0 0 {name=l2058 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -7560 0 0 {name=l2059 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -7600 0 0 {name=l2060 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -7620 0 0 {name=l2061 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -7640 0 0 {name=l2062 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -7660 0 0 {name=l2063 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -7310 3 0 {name=l2064 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -7360 2 1 {name=r1751}
C {devices/bus_connect_nolab.sym} 2810 -7380 2 1 {name=r1752}
C {devices/bus_connect_nolab.sym} 2810 -7400 2 1 {name=r1753}
C {devices/bus_connect_nolab.sym} 2810 -7420 2 1 {name=r1754}
C {devices/bus_connect_nolab.sym} 2810 -7440 2 1 {name=r1755}
C {devices/bus_connect_nolab.sym} 2810 -7460 2 1 {name=r1756}
C {devices/bus_connect_nolab.sym} 2810 -7480 2 1 {name=r1757}
C {devices/bus_connect_nolab.sym} 2810 -7500 2 1 {name=r1758}
C {devices/bus_connect_nolab.sym} 2810 -7520 2 1 {name=r1759}
C {devices/bus_connect_nolab.sym} 2810 -7540 2 1 {name=r1760}
C {devices/bus_connect_nolab.sym} 2810 -7560 2 1 {name=r1761}
C {devices/bus_connect_nolab.sym} 2810 -7580 2 1 {name=r1762}
C {devices/bus_connect_nolab.sym} 2810 -7600 2 1 {name=r1763}
C {devices/bus_connect_nolab.sym} 2810 -7620 2 1 {name=r1764}
C {devices/bus_connect_nolab.sym} 2810 -7640 2 1 {name=r1765}
C {devices/bus_connect_nolab.sym} 2810 -7660 2 1 {name=r1766}
C {devices/lab_pin.sym} 2820 -7310 3 0 {name=l2065 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -7660 0 1 {name=l2066 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -7640 0 1 {name=l2067 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -7620 0 1 {name=l2068 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -7600 0 1 {name=l2069 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -7580 0 1 {name=l2070 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -7560 0 1 {name=l2071 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -7540 0 1 {name=l2072 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -7520 0 1 {name=l2073 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -7500 0 1 {name=l2074 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -7480 0 1 {name=l2075 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -7460 0 1 {name=l2076 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -7440 0 1 {name=l2077 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -7420 0 1 {name=l2078 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -7400 0 1 {name=l2079 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -7380 0 1 {name=l2080 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -7360 0 1 {name=l2081 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -6680 2 0 {name=r1767}
C {devices/bus_connect_nolab.sym} 2340 -6700 2 0 {name=r1768}
C {devices/bus_connect_nolab.sym} 2340 -6720 2 0 {name=r1769}
C {devices/bus_connect_nolab.sym} 2340 -6740 2 0 {name=r1770}
C {devices/bus_connect_nolab.sym} 2340 -6760 2 0 {name=r1771}
C {devices/bus_connect_nolab.sym} 2340 -6780 2 0 {name=r1772}
C {devices/bus_connect_nolab.sym} 2340 -6800 2 0 {name=r1773}
C {devices/bus_connect_nolab.sym} 2340 -6820 2 0 {name=r1774}
C {devices/bus_connect_nolab.sym} 2340 -6840 2 0 {name=r1775}
C {devices/bus_connect_nolab.sym} 2340 -6860 2 0 {name=r1776}
C {devices/bus_connect_nolab.sym} 2340 -6880 2 0 {name=r1777}
C {devices/bus_connect_nolab.sym} 2340 -6900 2 0 {name=r1778}
C {devices/bus_connect_nolab.sym} 2340 -6920 2 0 {name=r1779}
C {devices/bus_connect_nolab.sym} 2340 -6940 2 0 {name=r1780}
C {devices/bus_connect_nolab.sym} 2340 -6960 2 0 {name=r1781}
C {devices/bus_connect_nolab.sym} 2340 -6980 2 0 {name=r1782}
C {devices/lab_pin.sym} 2330 -6640 3 0 {name=l2082 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -6680 2 1 {name=r1783}
C {devices/bus_connect_nolab.sym} 2760 -6700 2 1 {name=r1784}
C {devices/bus_connect_nolab.sym} 2760 -6720 2 1 {name=r1785}
C {devices/bus_connect_nolab.sym} 2760 -6740 2 1 {name=r1786}
C {devices/bus_connect_nolab.sym} 2760 -6760 2 1 {name=r1787}
C {devices/bus_connect_nolab.sym} 2760 -6780 2 1 {name=r1788}
C {devices/bus_connect_nolab.sym} 2760 -6800 2 1 {name=r1789}
C {devices/bus_connect_nolab.sym} 2760 -6820 2 1 {name=r1790}
C {devices/bus_connect_nolab.sym} 2760 -6840 2 1 {name=r1791}
C {devices/bus_connect_nolab.sym} 2760 -6860 2 1 {name=r1792}
C {devices/bus_connect_nolab.sym} 2760 -6880 2 1 {name=r1793}
C {devices/bus_connect_nolab.sym} 2760 -6900 2 1 {name=r1794}
C {devices/bus_connect_nolab.sym} 2760 -6920 2 1 {name=r1795}
C {devices/bus_connect_nolab.sym} 2760 -6940 2 1 {name=r1796}
C {devices/bus_connect_nolab.sym} 2760 -6960 2 1 {name=r1797}
C {devices/bus_connect_nolab.sym} 2760 -6980 2 1 {name=r1798}
C {devices/lab_pin.sym} 2770 -6640 1 1 {name=l2083 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -6700 0 0 {name=l2084 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -6720 0 0 {name=l2085 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -6740 0 0 {name=l2086 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -6760 0 0 {name=l2087 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -6780 0 0 {name=l2088 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -6800 0 0 {name=l2089 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -6820 0 0 {name=l2090 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -6840 0 0 {name=l2091 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -6860 0 0 {name=l2092 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -6900 0 0 {name=l2093 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -6880 0 0 {name=l2094 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -6920 0 0 {name=l2095 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -6940 0 0 {name=l2096 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -6960 0 0 {name=l2097 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -6980 0 0 {name=l2098 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -6680 0 0 {name=l2099 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -6700 0 1 {name=l2100 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -6720 0 1 {name=l2101 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -6740 0 1 {name=l2102 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -6760 0 1 {name=l2103 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -6780 0 1 {name=l2104 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -6800 0 1 {name=l2105 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -6820 0 1 {name=l2106 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -6840 0 1 {name=l2107 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -6860 0 1 {name=l2108 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -6900 0 1 {name=l2109 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -6880 0 1 {name=l2110 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -6920 0 1 {name=l2111 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -6940 0 1 {name=l2112 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -6960 0 1 {name=l2113 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -6980 0 1 {name=l2114 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -6680 0 1 {name=l2115 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -7350 2 0 {name=r1799}
C {devices/bus_connect_nolab.sym} 2890 -7370 2 0 {name=r1800}
C {devices/bus_connect_nolab.sym} 2890 -7390 2 0 {name=r1801}
C {devices/bus_connect_nolab.sym} 2890 -7410 2 0 {name=r1802}
C {devices/bus_connect_nolab.sym} 2890 -7430 2 0 {name=r1803}
C {devices/bus_connect_nolab.sym} 2890 -7450 2 0 {name=r1804}
C {devices/bus_connect_nolab.sym} 2890 -7470 2 0 {name=r1805}
C {devices/bus_connect_nolab.sym} 2890 -7490 2 0 {name=r1806}
C {devices/bus_connect_nolab.sym} 2890 -7510 2 0 {name=r1807}
C {devices/bus_connect_nolab.sym} 2890 -7530 2 0 {name=r1808}
C {devices/bus_connect_nolab.sym} 2890 -7570 2 0 {name=r1809}
C {devices/bus_connect_nolab.sym} 2890 -7550 2 0 {name=r1810}
C {devices/bus_connect_nolab.sym} 2890 -7610 2 0 {name=r1811}
C {devices/bus_connect_nolab.sym} 2890 -7590 2 0 {name=r1812}
C {devices/bus_connect_nolab.sym} 2890 -7650 2 0 {name=r1813}
C {devices/bus_connect_nolab.sym} 2890 -7630 2 0 {name=r1814}
C {devices/lab_wire.sym} 2940 -7350 0 0 {name=l2116 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -7370 0 0 {name=l2117 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -7390 0 0 {name=l2118 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -7390 0 0 {name=l2119 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -7410 0 0 {name=l2120 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -7430 0 0 {name=l2121 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -7450 0 0 {name=l2122 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -7470 0 0 {name=l2123 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -7490 0 0 {name=l2124 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -7510 0 0 {name=l2125 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -7530 0 0 {name=l2126 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -7570 0 0 {name=l2127 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -7550 0 0 {name=l2128 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -7590 0 0 {name=l2129 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -7610 0 0 {name=l2130 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -7630 0 0 {name=l2131 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -7650 0 0 {name=l2132 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -7300 3 0 {name=l2133 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -7350 2 1 {name=r1815}
C {devices/bus_connect_nolab.sym} 3510 -7370 2 1 {name=r1816}
C {devices/bus_connect_nolab.sym} 3510 -7390 2 1 {name=r1817}
C {devices/bus_connect_nolab.sym} 3510 -7410 2 1 {name=r1818}
C {devices/bus_connect_nolab.sym} 3510 -7430 2 1 {name=r1819}
C {devices/bus_connect_nolab.sym} 3510 -7450 2 1 {name=r1820}
C {devices/bus_connect_nolab.sym} 3510 -7470 2 1 {name=r1821}
C {devices/bus_connect_nolab.sym} 3510 -7490 2 1 {name=r1822}
C {devices/bus_connect_nolab.sym} 3510 -7510 2 1 {name=r1823}
C {devices/bus_connect_nolab.sym} 3510 -7530 2 1 {name=r1824}
C {devices/bus_connect_nolab.sym} 3510 -7550 2 1 {name=r1825}
C {devices/bus_connect_nolab.sym} 3510 -7570 2 1 {name=r1826}
C {devices/bus_connect_nolab.sym} 3510 -7590 2 1 {name=r1827}
C {devices/bus_connect_nolab.sym} 3510 -7610 2 1 {name=r1828}
C {devices/bus_connect_nolab.sym} 3510 -7630 2 1 {name=r1829}
C {devices/bus_connect_nolab.sym} 3510 -7650 2 1 {name=r1830}
C {devices/lab_pin.sym} 3520 -7300 3 0 {name=l2134 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -7650 0 1 {name=l2135 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -7630 0 1 {name=l2136 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -7610 0 1 {name=l2137 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -7590 0 1 {name=l2138 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -7570 0 1 {name=l2139 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -7550 0 1 {name=l2140 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -7530 0 1 {name=l2141 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -7510 0 1 {name=l2142 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -7490 0 1 {name=l2143 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -7470 0 1 {name=l2144 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -7450 0 1 {name=l2145 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -7430 0 1 {name=l2146 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -7410 0 1 {name=l2147 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -7390 0 1 {name=l2148 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -7370 0 1 {name=l2149 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -7350 0 1 {name=l2150 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -6670 2 0 {name=r1831}
C {devices/bus_connect_nolab.sym} 3040 -6690 2 0 {name=r1832}
C {devices/bus_connect_nolab.sym} 3040 -6710 2 0 {name=r1833}
C {devices/bus_connect_nolab.sym} 3040 -6730 2 0 {name=r1834}
C {devices/bus_connect_nolab.sym} 3040 -6750 2 0 {name=r1835}
C {devices/bus_connect_nolab.sym} 3040 -6770 2 0 {name=r1836}
C {devices/bus_connect_nolab.sym} 3040 -6790 2 0 {name=r1837}
C {devices/bus_connect_nolab.sym} 3040 -6810 2 0 {name=r1838}
C {devices/bus_connect_nolab.sym} 3040 -6830 2 0 {name=r1839}
C {devices/bus_connect_nolab.sym} 3040 -6850 2 0 {name=r1840}
C {devices/bus_connect_nolab.sym} 3040 -6870 2 0 {name=r1841}
C {devices/bus_connect_nolab.sym} 3040 -6890 2 0 {name=r1842}
C {devices/bus_connect_nolab.sym} 3040 -6910 2 0 {name=r1843}
C {devices/bus_connect_nolab.sym} 3040 -6930 2 0 {name=r1844}
C {devices/bus_connect_nolab.sym} 3040 -6950 2 0 {name=r1845}
C {devices/bus_connect_nolab.sym} 3040 -6970 2 0 {name=r1846}
C {devices/lab_pin.sym} 3030 -6630 3 0 {name=l2151 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -6670 2 1 {name=r1847}
C {devices/bus_connect_nolab.sym} 3460 -6690 2 1 {name=r1848}
C {devices/bus_connect_nolab.sym} 3460 -6710 2 1 {name=r1849}
C {devices/bus_connect_nolab.sym} 3460 -6730 2 1 {name=r1850}
C {devices/bus_connect_nolab.sym} 3460 -6750 2 1 {name=r1851}
C {devices/bus_connect_nolab.sym} 3460 -6770 2 1 {name=r1852}
C {devices/bus_connect_nolab.sym} 3460 -6790 2 1 {name=r1853}
C {devices/bus_connect_nolab.sym} 3460 -6810 2 1 {name=r1854}
C {devices/bus_connect_nolab.sym} 3460 -6830 2 1 {name=r1855}
C {devices/bus_connect_nolab.sym} 3460 -6850 2 1 {name=r1856}
C {devices/bus_connect_nolab.sym} 3460 -6870 2 1 {name=r1857}
C {devices/bus_connect_nolab.sym} 3460 -6890 2 1 {name=r1858}
C {devices/bus_connect_nolab.sym} 3460 -6910 2 1 {name=r1859}
C {devices/bus_connect_nolab.sym} 3460 -6930 2 1 {name=r1860}
C {devices/bus_connect_nolab.sym} 3460 -6950 2 1 {name=r1861}
C {devices/bus_connect_nolab.sym} 3460 -6970 2 1 {name=r1862}
C {devices/lab_pin.sym} 3470 -6630 1 1 {name=l2152 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -6690 0 0 {name=l2153 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -6710 0 0 {name=l2154 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -6730 0 0 {name=l2155 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -6750 0 0 {name=l2156 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -6770 0 0 {name=l2157 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -6790 0 0 {name=l2158 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -6810 0 0 {name=l2159 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -6830 0 0 {name=l2160 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -6850 0 0 {name=l2161 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -6890 0 0 {name=l2162 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -6870 0 0 {name=l2163 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -6910 0 0 {name=l2164 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -6930 0 0 {name=l2165 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -6950 0 0 {name=l2166 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -6970 0 0 {name=l2167 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -6670 0 0 {name=l2168 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -6690 0 1 {name=l2169 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -6710 0 1 {name=l2170 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -6730 0 1 {name=l2171 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -6750 0 1 {name=l2172 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -6770 0 1 {name=l2173 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -6790 0 1 {name=l2174 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -6810 0 1 {name=l2175 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -6830 0 1 {name=l2176 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -6850 0 1 {name=l2177 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -6890 0 1 {name=l2178 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -6870 0 1 {name=l2179 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -6910 0 1 {name=l2180 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -6930 0 1 {name=l2181 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -6950 0 1 {name=l2182 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -6970 0 1 {name=l2183 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -6670 0 1 {name=l2184 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -7350 2 0 {name=r1863}
C {devices/bus_connect_nolab.sym} 3600 -7370 2 0 {name=r1864}
C {devices/bus_connect_nolab.sym} 3600 -7390 2 0 {name=r1865}
C {devices/bus_connect_nolab.sym} 3600 -7410 2 0 {name=r1866}
C {devices/bus_connect_nolab.sym} 3600 -7430 2 0 {name=r1867}
C {devices/bus_connect_nolab.sym} 3600 -7450 2 0 {name=r1868}
C {devices/bus_connect_nolab.sym} 3600 -7470 2 0 {name=r1869}
C {devices/bus_connect_nolab.sym} 3600 -7490 2 0 {name=r1870}
C {devices/bus_connect_nolab.sym} 3600 -7510 2 0 {name=r1871}
C {devices/bus_connect_nolab.sym} 3600 -7530 2 0 {name=r1872}
C {devices/bus_connect_nolab.sym} 3600 -7570 2 0 {name=r1873}
C {devices/bus_connect_nolab.sym} 3600 -7550 2 0 {name=r1874}
C {devices/bus_connect_nolab.sym} 3600 -7610 2 0 {name=r1875}
C {devices/bus_connect_nolab.sym} 3600 -7590 2 0 {name=r1876}
C {devices/bus_connect_nolab.sym} 3600 -7650 2 0 {name=r1877}
C {devices/bus_connect_nolab.sym} 3600 -7630 2 0 {name=r1878}
C {devices/lab_wire.sym} 3650 -7350 0 0 {name=l2185 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -7370 0 0 {name=l2186 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -7390 0 0 {name=l2187 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -7390 0 0 {name=l2188 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -7410 0 0 {name=l2189 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -7430 0 0 {name=l2190 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -7450 0 0 {name=l2191 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -7470 0 0 {name=l2192 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -7490 0 0 {name=l2193 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -7510 0 0 {name=l2194 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -7530 0 0 {name=l2195 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -7570 0 0 {name=l2196 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -7550 0 0 {name=l2197 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -7590 0 0 {name=l2198 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -7610 0 0 {name=l2199 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -7630 0 0 {name=l2200 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -7650 0 0 {name=l2201 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -7300 3 0 {name=l2202 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -7350 2 1 {name=r1879}
C {devices/bus_connect_nolab.sym} 4220 -7370 2 1 {name=r1880}
C {devices/bus_connect_nolab.sym} 4220 -7390 2 1 {name=r1881}
C {devices/bus_connect_nolab.sym} 4220 -7410 2 1 {name=r1882}
C {devices/bus_connect_nolab.sym} 4220 -7430 2 1 {name=r1883}
C {devices/bus_connect_nolab.sym} 4220 -7450 2 1 {name=r1884}
C {devices/bus_connect_nolab.sym} 4220 -7470 2 1 {name=r1885}
C {devices/bus_connect_nolab.sym} 4220 -7490 2 1 {name=r1886}
C {devices/bus_connect_nolab.sym} 4220 -7510 2 1 {name=r1887}
C {devices/bus_connect_nolab.sym} 4220 -7530 2 1 {name=r1888}
C {devices/bus_connect_nolab.sym} 4220 -7550 2 1 {name=r1889}
C {devices/bus_connect_nolab.sym} 4220 -7570 2 1 {name=r1890}
C {devices/bus_connect_nolab.sym} 4220 -7590 2 1 {name=r1891}
C {devices/bus_connect_nolab.sym} 4220 -7610 2 1 {name=r1892}
C {devices/bus_connect_nolab.sym} 4220 -7630 2 1 {name=r1893}
C {devices/bus_connect_nolab.sym} 4220 -7650 2 1 {name=r1894}
C {devices/lab_pin.sym} 4230 -7300 3 0 {name=l2203 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -7650 0 1 {name=l2204 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -7630 0 1 {name=l2205 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -7610 0 1 {name=l2206 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -7590 0 1 {name=l2207 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -7570 0 1 {name=l2208 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -7550 0 1 {name=l2209 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -7530 0 1 {name=l2210 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -7510 0 1 {name=l2211 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -7490 0 1 {name=l2212 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -7470 0 1 {name=l2213 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -7450 0 1 {name=l2214 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -7430 0 1 {name=l2215 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -7410 0 1 {name=l2216 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -7390 0 1 {name=l2217 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -7370 0 1 {name=l2218 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -7350 0 1 {name=l2219 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -6670 2 0 {name=r1895}
C {devices/bus_connect_nolab.sym} 3750 -6690 2 0 {name=r1896}
C {devices/bus_connect_nolab.sym} 3750 -6710 2 0 {name=r1897}
C {devices/bus_connect_nolab.sym} 3750 -6730 2 0 {name=r1898}
C {devices/bus_connect_nolab.sym} 3750 -6750 2 0 {name=r1899}
C {devices/bus_connect_nolab.sym} 3750 -6770 2 0 {name=r1900}
C {devices/bus_connect_nolab.sym} 3750 -6790 2 0 {name=r1901}
C {devices/bus_connect_nolab.sym} 3750 -6810 2 0 {name=r1902}
C {devices/bus_connect_nolab.sym} 3750 -6830 2 0 {name=r1903}
C {devices/bus_connect_nolab.sym} 3750 -6850 2 0 {name=r1904}
C {devices/bus_connect_nolab.sym} 3750 -6870 2 0 {name=r1905}
C {devices/bus_connect_nolab.sym} 3750 -6890 2 0 {name=r1906}
C {devices/bus_connect_nolab.sym} 3750 -6910 2 0 {name=r1907}
C {devices/bus_connect_nolab.sym} 3750 -6930 2 0 {name=r1908}
C {devices/bus_connect_nolab.sym} 3750 -6950 2 0 {name=r1909}
C {devices/bus_connect_nolab.sym} 3750 -6970 2 0 {name=r1910}
C {devices/lab_pin.sym} 3740 -6630 3 0 {name=l2220 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -6670 2 1 {name=r1911}
C {devices/bus_connect_nolab.sym} 4170 -6690 2 1 {name=r1912}
C {devices/bus_connect_nolab.sym} 4170 -6710 2 1 {name=r1913}
C {devices/bus_connect_nolab.sym} 4170 -6730 2 1 {name=r1914}
C {devices/bus_connect_nolab.sym} 4170 -6750 2 1 {name=r1915}
C {devices/bus_connect_nolab.sym} 4170 -6770 2 1 {name=r1916}
C {devices/bus_connect_nolab.sym} 4170 -6790 2 1 {name=r1917}
C {devices/bus_connect_nolab.sym} 4170 -6810 2 1 {name=r1918}
C {devices/bus_connect_nolab.sym} 4170 -6830 2 1 {name=r1919}
C {devices/bus_connect_nolab.sym} 4170 -6850 2 1 {name=r1920}
C {devices/bus_connect_nolab.sym} 4170 -6870 2 1 {name=r1921}
C {devices/bus_connect_nolab.sym} 4170 -6890 2 1 {name=r1922}
C {devices/bus_connect_nolab.sym} 4170 -6910 2 1 {name=r1923}
C {devices/bus_connect_nolab.sym} 4170 -6930 2 1 {name=r1924}
C {devices/bus_connect_nolab.sym} 4170 -6950 2 1 {name=r1925}
C {devices/bus_connect_nolab.sym} 4170 -6970 2 1 {name=r1926}
C {devices/lab_pin.sym} 4180 -6630 1 1 {name=l2221 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -6690 0 0 {name=l2222 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -6710 0 0 {name=l2223 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -6730 0 0 {name=l2224 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -6750 0 0 {name=l2225 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -6770 0 0 {name=l2226 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -6790 0 0 {name=l2227 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -6810 0 0 {name=l2228 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3790 -6830 0 0 {name=l2229 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -6850 0 0 {name=l2230 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -6890 0 0 {name=l2231 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -6870 0 0 {name=l2232 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -6910 0 0 {name=l2233 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -6930 0 0 {name=l2234 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -6950 0 0 {name=l2235 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -6970 0 0 {name=l2236 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -6670 0 0 {name=l2237 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -6690 0 1 {name=l2238 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -6710 0 1 {name=l2239 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -6730 0 1 {name=l2240 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -6750 0 1 {name=l2241 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -6770 0 1 {name=l2242 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -6790 0 1 {name=l2243 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -6810 0 1 {name=l2244 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -6830 0 1 {name=l2245 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -6850 0 1 {name=l2246 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -6890 0 1 {name=l2247 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -6870 0 1 {name=l2248 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -6910 0 1 {name=l2249 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -6930 0 1 {name=l2250 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -6950 0 1 {name=l2251 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -6970 0 1 {name=l2252 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -6670 0 1 {name=l2253 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -7840 2 1 {name=l2254 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -7860 0 0 {name=l2255 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -7960 0 0 {name=l2256 lab=row3_sel}
C {devices/lab_pin.sym} 2340 -7940 0 0 {name=l2257 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -7880 0 0 {name=l2258 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -7920 0 0 {name=l2259 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -7900 0 0 {name=l2260 lab=WR}
C {devices/lab_pin.sym} 2340 -7820 2 1 {name=l2261 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -7760 0 0 {name=l2262 lab=Vref}
C {devices/lab_pin.sym} 2340 -7720 0 0 {name=l2263 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -7740 0 0 {name=l2264 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -7780 2 1 {name=l2265 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -7800 2 1 {name=l2266 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -7830 2 1 {name=l2267 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -7850 0 0 {name=l2268 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -7950 0 0 {name=l2269 lab=row3_sel}
C {devices/lab_pin.sym} 3040 -7930 0 0 {name=l2270 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -7870 0 0 {name=l2271 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -7910 0 0 {name=l2272 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -7890 0 0 {name=l2273 lab=WR}
C {devices/lab_pin.sym} 3040 -7810 2 1 {name=l2274 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -7750 0 0 {name=l2275 lab=Vref}
C {devices/lab_pin.sym} 3040 -7710 0 0 {name=l2276 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -7730 0 0 {name=l2277 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -7770 2 1 {name=l2278 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -7790 2 1 {name=l2279 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -7830 2 1 {name=l2280 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -7850 0 0 {name=l2281 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -7950 0 0 {name=l2282 lab=row3_sel}
C {devices/lab_pin.sym} 3750 -7930 0 0 {name=l2283 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -7870 0 0 {name=l2284 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -7910 0 0 {name=l2285 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -7890 0 0 {name=l2286 lab=WR}
C {devices/lab_pin.sym} 3750 -7810 2 1 {name=l2287 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -7750 0 0 {name=l2288 lab=Vref}
C {devices/lab_pin.sym} 3750 -7710 0 0 {name=l2289 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -7730 0 0 {name=l2290 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -7770 2 1 {name=l2291 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -7790 2 1 {name=l2292 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -7840 2 1 {name=l2293 lab=Vrminus}
C {devices/lab_pin.sym} 190 -7860 0 0 {name=l2294 lab=SAMPLE}
C {devices/lab_pin.sym} 190 -7880 0 0 {name=l2295 lab=Vgpr}
C {devices/lab_pin.sym} 190 -7920 0 0 {name=l2296 lab=Vgnr}
C {devices/lab_pin.sym} 190 -7900 0 0 {name=l2297 lab=WR}
C {devices/lab_pin.sym} 190 -7820 2 1 {name=l2298 lab=Vrplus}
C {devices/lab_pin.sym} 190 -7760 0 0 {name=l2299 lab=Vref}
C {devices/lab_pin.sym} 190 -7720 0 0 {name=l2300 lab=Vcplus}
C {devices/lab_pin.sym} 190 -7740 0 0 {name=l2301 lab=Vcminus}
C {devices/lab_pin.sym} 190 -7780 2 1 {name=l2302 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 190 -7800 2 1 {name=l2303 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 610 -7920 2 0 {name=l2304 lab=vdda1}
C {devices/lab_pin.sym} 610 -7940 2 0 {name=l2306 lab=vccd1}
C {devices/lab_pin.sym} 610 -7960 2 0 {name=l2307 lab=latch_high0}
C {devices/lab_pin.sym} 2030 -7950 2 0 {name=l2308 lab=latch_high2}
C {devices/lab_pin.sym} 2760 -7960 2 0 {name=l2309 lab=latch_high3}
C {devices/lab_pin.sym} 3460 -7950 2 0 {name=l2310 lab=latch_high4}
C {devices/lab_pin.sym} 4170 -7950 2 0 {name=l2311 lab=latch_high5}
C {devices/lab_pin.sym} 1330 -7960 2 0 {name=l2312 lab=latch_high1}
C {devices/lab_pin.sym} 190 -9950 0 0 {name=l2313 lab=row4_sel}
C {devices/lab_pin.sym} 190 -9930 0 0 {name=l2314 lab=col0_sel}
C {devices/lab_pin.sym} 910 -9830 2 1 {name=l2315 lab=Vrminus}
C {devices/lab_pin.sym} 910 -9850 0 0 {name=l2316 lab=SAMPLE}
C {devices/lab_pin.sym} 2760 -9910 2 0 {name=l2317 lab=vdda1}
C {devices/lab_pin.sym} 2760 -9930 2 0 {name=l2319 lab=vccd1}
C {devices/lab_pin.sym} 3460 -9900 2 0 {name=l2320 lab=vdda1}
C {devices/lab_pin.sym} 3460 -9920 2 0 {name=l2322 lab=vccd1}
C {devices/lab_pin.sym} 4170 -9900 2 0 {name=l2323 lab=vdda1}
C {devices/lab_pin.sym} 4170 -9920 2 0 {name=l2325 lab=vccd1}
C {devices/lab_wire.sym} 130 -9310 0 0 {name=l2326 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -9290 0 0 {name=l2327 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -9270 0 0 {name=l2328 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -9250 0 0 {name=l2329 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -9230 0 0 {name=l2330 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -9210 0 0 {name=l2331 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -9190 0 0 {name=l2332 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -9170 0 0 {name=l2333 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -9150 0 0 {name=l2334 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -9130 0 0 {name=l2335 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -9110 0 0 {name=l2336 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -9090 0 0 {name=l2337 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -9070 0 0 {name=l2338 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -9050 0 0 {name=l2339 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -9030 0 0 {name=l2340 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -9010 0 0 {name=l2341 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -8970 3 0 {name=l2342 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -9010 2 0 {name=r1927}
C {devices/bus_connect_nolab.sym} 70 -9030 2 0 {name=r1928}
C {devices/bus_connect_nolab.sym} 70 -9050 2 0 {name=r1929}
C {devices/bus_connect_nolab.sym} 70 -9070 2 0 {name=r1930}
C {devices/bus_connect_nolab.sym} 70 -9090 2 0 {name=r1931}
C {devices/bus_connect_nolab.sym} 70 -9110 2 0 {name=r1932}
C {devices/bus_connect_nolab.sym} 70 -9130 2 0 {name=r1933}
C {devices/bus_connect_nolab.sym} 70 -9150 2 0 {name=r1934}
C {devices/bus_connect_nolab.sym} 70 -9170 2 0 {name=r1935}
C {devices/bus_connect_nolab.sym} 70 -9190 2 0 {name=r1936}
C {devices/bus_connect_nolab.sym} 70 -9210 2 0 {name=r1937}
C {devices/bus_connect_nolab.sym} 70 -9230 2 0 {name=r1938}
C {devices/bus_connect_nolab.sym} 70 -9250 2 0 {name=r1939}
C {devices/bus_connect_nolab.sym} 70 -9270 2 0 {name=r1940}
C {devices/bus_connect_nolab.sym} 70 -9290 2 0 {name=r1941}
C {devices/bus_connect_nolab.sym} 70 -9310 2 0 {name=r1942}
C {devices/lab_wire.sym} 850 -9310 0 0 {name=l2343 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -9290 0 0 {name=l2344 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -9270 0 0 {name=l2345 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -9250 0 0 {name=l2346 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -9230 0 0 {name=l2347 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -9210 0 0 {name=l2348 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -9190 0 0 {name=l2349 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -9170 0 0 {name=l2350 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -9150 0 0 {name=l2351 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -9130 0 0 {name=l2352 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -9110 0 0 {name=l2353 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -9090 0 0 {name=l2354 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -9070 0 0 {name=l2355 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -9050 0 0 {name=l2356 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -9030 0 0 {name=l2357 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -8970 3 0 {name=l2358 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -9010 2 0 {name=r1943}
C {devices/bus_connect_nolab.sym} 790 -9030 2 0 {name=r1944}
C {devices/bus_connect_nolab.sym} 790 -9050 2 0 {name=r1945}
C {devices/bus_connect_nolab.sym} 790 -9070 2 0 {name=r1946}
C {devices/bus_connect_nolab.sym} 790 -9090 2 0 {name=r1947}
C {devices/bus_connect_nolab.sym} 790 -9110 2 0 {name=r1948}
C {devices/bus_connect_nolab.sym} 790 -9130 2 0 {name=r1949}
C {devices/bus_connect_nolab.sym} 790 -9150 2 0 {name=r1950}
C {devices/bus_connect_nolab.sym} 790 -9170 2 0 {name=r1951}
C {devices/bus_connect_nolab.sym} 790 -9190 2 0 {name=r1952}
C {devices/bus_connect_nolab.sym} 790 -9210 2 0 {name=r1953}
C {devices/bus_connect_nolab.sym} 790 -9230 2 0 {name=r1954}
C {devices/bus_connect_nolab.sym} 790 -9250 2 0 {name=r1955}
C {devices/bus_connect_nolab.sym} 790 -9270 2 0 {name=r1956}
C {devices/bus_connect_nolab.sym} 790 -9290 2 0 {name=r1957}
C {devices/bus_connect_nolab.sym} 790 -9310 2 0 {name=r1958}
C {devices/lab_wire.sym} 850 -9010 0 0 {name=l2359 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -9300 0 0 {name=l2360 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -9280 0 0 {name=l2361 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -9260 0 0 {name=l2362 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -9240 0 0 {name=l2363 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -9220 0 0 {name=l2364 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -9200 0 0 {name=l2365 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -9180 0 0 {name=l2366 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -9160 0 0 {name=l2367 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -9140 0 0 {name=l2368 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -9120 0 0 {name=l2369 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -9100 0 0 {name=l2370 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -9080 0 0 {name=l2371 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -9060 0 0 {name=l2372 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -9040 0 0 {name=l2373 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -9020 0 0 {name=l2374 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -8960 0 0 {name=l2375 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -9000 2 0 {name=r1959}
C {devices/bus_connect_nolab.sym} 1490 -9020 2 0 {name=r1960}
C {devices/bus_connect_nolab.sym} 1490 -9040 2 0 {name=r1961}
C {devices/bus_connect_nolab.sym} 1490 -9060 2 0 {name=r1962}
C {devices/bus_connect_nolab.sym} 1490 -9080 2 0 {name=r1963}
C {devices/bus_connect_nolab.sym} 1490 -9100 2 0 {name=r1964}
C {devices/bus_connect_nolab.sym} 1490 -9120 2 0 {name=r1965}
C {devices/bus_connect_nolab.sym} 1490 -9140 2 0 {name=r1966}
C {devices/bus_connect_nolab.sym} 1490 -9160 2 0 {name=r1967}
C {devices/bus_connect_nolab.sym} 1490 -9180 2 0 {name=r1968}
C {devices/bus_connect_nolab.sym} 1490 -9200 2 0 {name=r1969}
C {devices/bus_connect_nolab.sym} 1490 -9220 2 0 {name=r1970}
C {devices/bus_connect_nolab.sym} 1490 -9240 2 0 {name=r1971}
C {devices/bus_connect_nolab.sym} 1490 -9260 2 0 {name=r1972}
C {devices/bus_connect_nolab.sym} 1490 -9280 2 0 {name=r1973}
C {devices/bus_connect_nolab.sym} 1490 -9300 2 0 {name=r1974}
C {devices/lab_wire.sym} 1550 -9000 0 0 {name=l2376 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -9310 0 0 {name=l2377 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -9290 0 0 {name=l2378 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -9270 0 0 {name=l2379 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -9250 0 0 {name=l2380 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -9230 0 0 {name=l2381 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -9210 0 0 {name=l2382 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -9190 0 0 {name=l2383 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -9170 0 0 {name=l2384 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -9150 0 0 {name=l2385 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -9130 0 0 {name=l2386 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -9110 0 0 {name=l2387 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -9090 0 0 {name=l2388 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -9070 0 0 {name=l2389 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -9050 0 0 {name=l2390 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -9030 0 0 {name=l2391 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -8970 0 0 {name=l2392 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -9010 2 0 {name=r1975}
C {devices/bus_connect_nolab.sym} 2220 -9030 2 0 {name=r1976}
C {devices/bus_connect_nolab.sym} 2220 -9050 2 0 {name=r1977}
C {devices/bus_connect_nolab.sym} 2220 -9070 2 0 {name=r1978}
C {devices/bus_connect_nolab.sym} 2220 -9090 2 0 {name=r1979}
C {devices/bus_connect_nolab.sym} 2220 -9110 2 0 {name=r1980}
C {devices/bus_connect_nolab.sym} 2220 -9130 2 0 {name=r1981}
C {devices/bus_connect_nolab.sym} 2220 -9150 2 0 {name=r1982}
C {devices/bus_connect_nolab.sym} 2220 -9170 2 0 {name=r1983}
C {devices/bus_connect_nolab.sym} 2220 -9190 2 0 {name=r1984}
C {devices/bus_connect_nolab.sym} 2220 -9210 2 0 {name=r1985}
C {devices/bus_connect_nolab.sym} 2220 -9230 2 0 {name=r1986}
C {devices/bus_connect_nolab.sym} 2220 -9250 2 0 {name=r1987}
C {devices/bus_connect_nolab.sym} 2220 -9270 2 0 {name=r1988}
C {devices/bus_connect_nolab.sym} 2220 -9290 2 0 {name=r1989}
C {devices/bus_connect_nolab.sym} 2220 -9310 2 0 {name=r1990}
C {devices/lab_wire.sym} 2280 -9010 0 0 {name=l2393 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -9300 0 0 {name=l2394 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -9280 0 0 {name=l2395 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -9260 0 0 {name=l2396 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -9240 0 0 {name=l2397 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -9220 0 0 {name=l2398 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -9200 0 0 {name=l2399 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -9180 0 0 {name=l2400 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -9160 0 0 {name=l2401 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -9140 0 0 {name=l2402 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -9120 0 0 {name=l2403 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -9100 0 0 {name=l2404 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -9080 0 0 {name=l2405 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -9060 0 0 {name=l2406 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -9040 0 0 {name=l2407 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -9020 0 0 {name=l2408 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -8960 0 0 {name=l2409 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -9000 2 0 {name=r1991}
C {devices/bus_connect_nolab.sym} 2920 -9020 2 0 {name=r1992}
C {devices/bus_connect_nolab.sym} 2920 -9040 2 0 {name=r1993}
C {devices/bus_connect_nolab.sym} 2920 -9060 2 0 {name=r1994}
C {devices/bus_connect_nolab.sym} 2920 -9080 2 0 {name=r1995}
C {devices/bus_connect_nolab.sym} 2920 -9100 2 0 {name=r1996}
C {devices/bus_connect_nolab.sym} 2920 -9120 2 0 {name=r1997}
C {devices/bus_connect_nolab.sym} 2920 -9140 2 0 {name=r1998}
C {devices/bus_connect_nolab.sym} 2920 -9160 2 0 {name=r1999}
C {devices/bus_connect_nolab.sym} 2920 -9180 2 0 {name=r2000}
C {devices/bus_connect_nolab.sym} 2920 -9200 2 0 {name=r2001}
C {devices/bus_connect_nolab.sym} 2920 -9220 2 0 {name=r2002}
C {devices/bus_connect_nolab.sym} 2920 -9240 2 0 {name=r2003}
C {devices/bus_connect_nolab.sym} 2920 -9260 2 0 {name=r2004}
C {devices/bus_connect_nolab.sym} 2920 -9280 2 0 {name=r2005}
C {devices/bus_connect_nolab.sym} 2920 -9300 2 0 {name=r2006}
C {devices/lab_wire.sym} 2980 -9000 0 0 {name=l2410 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -9300 0 0 {name=l2411 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -9280 0 0 {name=l2412 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -9260 0 0 {name=l2413 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -9240 0 0 {name=l2414 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -9220 0 0 {name=l2415 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -9200 0 0 {name=l2416 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -9180 0 0 {name=l2417 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -9160 0 0 {name=l2418 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -9140 0 0 {name=l2419 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -9120 0 0 {name=l2420 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -9100 0 0 {name=l2421 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -9080 0 0 {name=l2422 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -9060 0 0 {name=l2423 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -9040 0 0 {name=l2424 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -9020 0 0 {name=l2425 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -8960 0 0 {name=l2426 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -9000 2 0 {name=r2007}
C {devices/bus_connect_nolab.sym} 3630 -9020 2 0 {name=r2008}
C {devices/bus_connect_nolab.sym} 3630 -9040 2 0 {name=r2009}
C {devices/bus_connect_nolab.sym} 3630 -9060 2 0 {name=r2010}
C {devices/bus_connect_nolab.sym} 3630 -9080 2 0 {name=r2011}
C {devices/bus_connect_nolab.sym} 3630 -9100 2 0 {name=r2012}
C {devices/bus_connect_nolab.sym} 3630 -9120 2 0 {name=r2013}
C {devices/bus_connect_nolab.sym} 3630 -9140 2 0 {name=r2014}
C {devices/bus_connect_nolab.sym} 3630 -9160 2 0 {name=r2015}
C {devices/bus_connect_nolab.sym} 3630 -9180 2 0 {name=r2016}
C {devices/bus_connect_nolab.sym} 3630 -9200 2 0 {name=r2017}
C {devices/bus_connect_nolab.sym} 3630 -9220 2 0 {name=r2018}
C {devices/bus_connect_nolab.sym} 3630 -9240 2 0 {name=r2019}
C {devices/bus_connect_nolab.sym} 3630 -9260 2 0 {name=r2020}
C {devices/bus_connect_nolab.sym} 3630 -9280 2 0 {name=r2021}
C {devices/bus_connect_nolab.sym} 3630 -9300 2 0 {name=r2022}
C {devices/lab_wire.sym} 3690 -9000 0 0 {name=l2427 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} 40 -9350 2 0 {name=r2023}
C {devices/bus_connect_nolab.sym} 40 -9370 2 0 {name=r2024}
C {devices/bus_connect_nolab.sym} 40 -9390 2 0 {name=r2025}
C {devices/bus_connect_nolab.sym} 40 -9410 2 0 {name=r2026}
C {devices/bus_connect_nolab.sym} 40 -9430 2 0 {name=r2027}
C {devices/bus_connect_nolab.sym} 40 -9450 2 0 {name=r2028}
C {devices/bus_connect_nolab.sym} 40 -9470 2 0 {name=r2029}
C {devices/bus_connect_nolab.sym} 40 -9490 2 0 {name=r2030}
C {devices/bus_connect_nolab.sym} 40 -9510 2 0 {name=r2031}
C {devices/bus_connect_nolab.sym} 40 -9530 2 0 {name=r2032}
C {devices/bus_connect_nolab.sym} 40 -9570 2 0 {name=r2033}
C {devices/bus_connect_nolab.sym} 40 -9550 2 0 {name=r2034}
C {devices/bus_connect_nolab.sym} 40 -9610 2 0 {name=r2035}
C {devices/bus_connect_nolab.sym} 40 -9590 2 0 {name=r2036}
C {devices/bus_connect_nolab.sym} 40 -9650 2 0 {name=r2037}
C {devices/bus_connect_nolab.sym} 40 -9630 2 0 {name=r2038}
C {devices/lab_wire.sym} 90 -9350 0 0 {name=l2428 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -9370 0 0 {name=l2429 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -9390 0 0 {name=l2430 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -9390 0 0 {name=l2431 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -9410 0 0 {name=l2432 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -9430 0 0 {name=l2433 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -9450 0 0 {name=l2434 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -9470 0 0 {name=l2435 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -9490 0 0 {name=l2436 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -9510 0 0 {name=l2437 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -9530 0 0 {name=l2438 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -9570 0 0 {name=l2439 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -9550 0 0 {name=l2440 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -9590 0 0 {name=l2441 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -9610 0 0 {name=l2442 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -9630 0 0 {name=l2443 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -9650 0 0 {name=l2444 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -9300 3 0 {name=l2445 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -9350 2 1 {name=r2039}
C {devices/bus_connect_nolab.sym} 660 -9370 2 1 {name=r2040}
C {devices/bus_connect_nolab.sym} 660 -9390 2 1 {name=r2041}
C {devices/bus_connect_nolab.sym} 660 -9410 2 1 {name=r2042}
C {devices/bus_connect_nolab.sym} 660 -9430 2 1 {name=r2043}
C {devices/bus_connect_nolab.sym} 660 -9450 2 1 {name=r2044}
C {devices/bus_connect_nolab.sym} 660 -9470 2 1 {name=r2045}
C {devices/bus_connect_nolab.sym} 660 -9490 2 1 {name=r2046}
C {devices/bus_connect_nolab.sym} 660 -9510 2 1 {name=r2047}
C {devices/bus_connect_nolab.sym} 660 -9530 2 1 {name=r2048}
C {devices/bus_connect_nolab.sym} 660 -9550 2 1 {name=r2049}
C {devices/bus_connect_nolab.sym} 660 -9570 2 1 {name=r2050}
C {devices/bus_connect_nolab.sym} 660 -9590 2 1 {name=r2051}
C {devices/bus_connect_nolab.sym} 660 -9610 2 1 {name=r2052}
C {devices/bus_connect_nolab.sym} 660 -9630 2 1 {name=r2053}
C {devices/bus_connect_nolab.sym} 660 -9650 2 1 {name=r2054}
C {devices/lab_pin.sym} 670 -9300 3 0 {name=l2446 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -9650 0 1 {name=l2447 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -9630 0 1 {name=l2448 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -9610 0 1 {name=l2449 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -9590 0 1 {name=l2450 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -9570 0 1 {name=l2451 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -9550 0 1 {name=l2452 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -9530 0 1 {name=l2453 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -9510 0 1 {name=l2454 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -9490 0 1 {name=l2455 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -9470 0 1 {name=l2456 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -9450 0 1 {name=l2457 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -9430 0 1 {name=l2458 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -9410 0 1 {name=l2459 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -9390 0 1 {name=l2460 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -9370 0 1 {name=l2461 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -9350 0 1 {name=l2462 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 190 -8670 2 0 {name=r2055}
C {devices/bus_connect_nolab.sym} 190 -8690 2 0 {name=r2056}
C {devices/bus_connect_nolab.sym} 190 -8710 2 0 {name=r2057}
C {devices/bus_connect_nolab.sym} 190 -8730 2 0 {name=r2058}
C {devices/bus_connect_nolab.sym} 190 -8750 2 0 {name=r2059}
C {devices/bus_connect_nolab.sym} 190 -8770 2 0 {name=r2060}
C {devices/bus_connect_nolab.sym} 190 -8790 2 0 {name=r2061}
C {devices/bus_connect_nolab.sym} 190 -8810 2 0 {name=r2062}
C {devices/bus_connect_nolab.sym} 190 -8830 2 0 {name=r2063}
C {devices/bus_connect_nolab.sym} 190 -8850 2 0 {name=r2064}
C {devices/bus_connect_nolab.sym} 190 -8870 2 0 {name=r2065}
C {devices/bus_connect_nolab.sym} 190 -8890 2 0 {name=r2066}
C {devices/bus_connect_nolab.sym} 190 -8910 2 0 {name=r2067}
C {devices/bus_connect_nolab.sym} 190 -8930 2 0 {name=r2068}
C {devices/bus_connect_nolab.sym} 190 -8950 2 0 {name=r2069}
C {devices/bus_connect_nolab.sym} 190 -8970 2 0 {name=r2070}
C {devices/lab_pin.sym} 180 -8630 3 0 {name=l2463 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -8670 2 1 {name=r2071}
C {devices/bus_connect_nolab.sym} 610 -8690 2 1 {name=r2072}
C {devices/bus_connect_nolab.sym} 610 -8710 2 1 {name=r2073}
C {devices/bus_connect_nolab.sym} 610 -8730 2 1 {name=r2074}
C {devices/bus_connect_nolab.sym} 610 -8750 2 1 {name=r2075}
C {devices/bus_connect_nolab.sym} 610 -8770 2 1 {name=r2076}
C {devices/bus_connect_nolab.sym} 610 -8790 2 1 {name=r2077}
C {devices/bus_connect_nolab.sym} 610 -8810 2 1 {name=r2078}
C {devices/bus_connect_nolab.sym} 610 -8830 2 1 {name=r2079}
C {devices/bus_connect_nolab.sym} 610 -8850 2 1 {name=r2080}
C {devices/bus_connect_nolab.sym} 610 -8870 2 1 {name=r2081}
C {devices/bus_connect_nolab.sym} 610 -8890 2 1 {name=r2082}
C {devices/bus_connect_nolab.sym} 610 -8910 2 1 {name=r2083}
C {devices/bus_connect_nolab.sym} 610 -8930 2 1 {name=r2084}
C {devices/bus_connect_nolab.sym} 610 -8950 2 1 {name=r2085}
C {devices/bus_connect_nolab.sym} 610 -8970 2 1 {name=r2086}
C {devices/lab_pin.sym} 620 -8630 1 1 {name=l2464 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -8690 0 0 {name=l2465 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -8710 0 0 {name=l2466 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -8730 0 0 {name=l2467 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -8750 0 0 {name=l2468 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -8770 0 0 {name=l2469 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -8790 0 0 {name=l2470 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -8810 0 0 {name=l2471 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -8830 0 0 {name=l2472 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -8850 0 0 {name=l2473 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -8890 0 0 {name=l2474 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -8870 0 0 {name=l2475 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -8910 0 0 {name=l2476 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -8930 0 0 {name=l2477 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -8950 0 0 {name=l2478 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -8970 0 0 {name=l2479 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -8670 0 0 {name=l2480 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -8690 0 1 {name=l2481 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -8710 0 1 {name=l2482 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -8730 0 1 {name=l2483 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -8750 0 1 {name=l2484 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -8770 0 1 {name=l2485 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -8790 0 1 {name=l2486 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -8810 0 1 {name=l2487 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -8830 0 1 {name=l2488 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -8850 0 1 {name=l2489 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -8890 0 1 {name=l2490 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -8870 0 1 {name=l2491 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -8910 0 1 {name=l2492 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -8930 0 1 {name=l2493 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -8950 0 1 {name=l2494 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -8970 0 1 {name=l2495 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -8670 0 1 {name=l2496 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -9950 0 0 {name=l2497 lab=row4_sel}
C {devices/lab_pin.sym} 910 -9930 0 0 {name=l2498 lab=col1_sel}
C {devices/bus_connect_nolab.sym} 760 -9350 2 0 {name=r2087}
C {devices/bus_connect_nolab.sym} 760 -9370 2 0 {name=r2088}
C {devices/bus_connect_nolab.sym} 760 -9390 2 0 {name=r2089}
C {devices/bus_connect_nolab.sym} 760 -9410 2 0 {name=r2090}
C {devices/bus_connect_nolab.sym} 760 -9430 2 0 {name=r2091}
C {devices/bus_connect_nolab.sym} 760 -9450 2 0 {name=r2092}
C {devices/bus_connect_nolab.sym} 760 -9470 2 0 {name=r2093}
C {devices/bus_connect_nolab.sym} 760 -9490 2 0 {name=r2094}
C {devices/bus_connect_nolab.sym} 760 -9510 2 0 {name=r2095}
C {devices/bus_connect_nolab.sym} 760 -9530 2 0 {name=r2096}
C {devices/bus_connect_nolab.sym} 760 -9570 2 0 {name=r2097}
C {devices/bus_connect_nolab.sym} 760 -9550 2 0 {name=r2098}
C {devices/bus_connect_nolab.sym} 760 -9610 2 0 {name=r2099}
C {devices/bus_connect_nolab.sym} 760 -9590 2 0 {name=r2100}
C {devices/bus_connect_nolab.sym} 760 -9650 2 0 {name=r2101}
C {devices/bus_connect_nolab.sym} 760 -9630 2 0 {name=r2102}
C {devices/lab_wire.sym} 810 -9350 0 0 {name=l2499 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -9370 0 0 {name=l2500 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -9390 0 0 {name=l2501 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -9390 0 0 {name=l2502 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -9410 0 0 {name=l2503 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -9430 0 0 {name=l2504 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -9450 0 0 {name=l2505 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -9470 0 0 {name=l2506 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -9490 0 0 {name=l2507 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -9510 0 0 {name=l2508 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -9530 0 0 {name=l2509 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -9570 0 0 {name=l2510 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -9550 0 0 {name=l2511 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -9590 0 0 {name=l2512 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -9610 0 0 {name=l2513 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -9630 0 0 {name=l2514 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -9650 0 0 {name=l2515 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -9300 3 0 {name=l2516 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -9350 2 1 {name=r2103}
C {devices/bus_connect_nolab.sym} 1380 -9370 2 1 {name=r2104}
C {devices/bus_connect_nolab.sym} 1380 -9390 2 1 {name=r2105}
C {devices/bus_connect_nolab.sym} 1380 -9410 2 1 {name=r2106}
C {devices/bus_connect_nolab.sym} 1380 -9430 2 1 {name=r2107}
C {devices/bus_connect_nolab.sym} 1380 -9450 2 1 {name=r2108}
C {devices/bus_connect_nolab.sym} 1380 -9470 2 1 {name=r2109}
C {devices/bus_connect_nolab.sym} 1380 -9490 2 1 {name=r2110}
C {devices/bus_connect_nolab.sym} 1380 -9510 2 1 {name=r2111}
C {devices/bus_connect_nolab.sym} 1380 -9530 2 1 {name=r2112}
C {devices/bus_connect_nolab.sym} 1380 -9550 2 1 {name=r2113}
C {devices/bus_connect_nolab.sym} 1380 -9570 2 1 {name=r2114}
C {devices/bus_connect_nolab.sym} 1380 -9590 2 1 {name=r2115}
C {devices/bus_connect_nolab.sym} 1380 -9610 2 1 {name=r2116}
C {devices/bus_connect_nolab.sym} 1380 -9630 2 1 {name=r2117}
C {devices/bus_connect_nolab.sym} 1380 -9650 2 1 {name=r2118}
C {devices/lab_pin.sym} 1390 -9300 3 0 {name=l2517 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -9650 0 1 {name=l2518 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -9630 0 1 {name=l2519 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -9610 0 1 {name=l2520 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -9590 0 1 {name=l2521 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -9570 0 1 {name=l2522 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -9550 0 1 {name=l2523 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -9530 0 1 {name=l2524 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -9510 0 1 {name=l2525 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -9490 0 1 {name=l2526 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -9470 0 1 {name=l2527 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -9450 0 1 {name=l2528 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -9430 0 1 {name=l2529 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -9410 0 1 {name=l2530 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -9390 0 1 {name=l2531 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -9370 0 1 {name=l2532 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -9350 0 1 {name=l2533 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -9870 0 0 {name=l2534 lab=Vgpr}
C {devices/lab_pin.sym} 910 -9910 0 0 {name=l2535 lab=Vgnr}
C {devices/lab_pin.sym} 910 -9890 0 0 {name=l2536 lab=WR}
C {devices/lab_pin.sym} 910 -9810 2 1 {name=l2537 lab=Vrplus}
C {devices/lab_pin.sym} 910 -9750 0 0 {name=l2538 lab=Vref}
C {devices/lab_pin.sym} 910 -9710 0 0 {name=l2539 lab=Vcplus}
C {devices/lab_pin.sym} 910 -9730 0 0 {name=l2540 lab=Vcminus}
C {devices/lab_pin.sym} 910 -9770 2 1 {name=l2541 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -9790 2 1 {name=l2542 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -9910 2 0 {name=l2543 lab=vdda1}
C {devices/lab_pin.sym} 1330 -9930 2 0 {name=l2545 lab=vccd1}
C {devices/lab_pin.sym} 1610 -9820 2 1 {name=l2546 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -9840 0 0 {name=l2547 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -9940 0 0 {name=l2548 lab=row4_sel}
C {devices/lab_pin.sym} 1610 -9920 0 0 {name=l2549 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -9860 0 0 {name=l2550 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -9900 0 0 {name=l2551 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -9880 0 0 {name=l2552 lab=WR}
C {devices/lab_pin.sym} 1610 -9800 2 1 {name=l2553 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -9740 0 0 {name=l2554 lab=Vref}
C {devices/lab_pin.sym} 1610 -9700 0 0 {name=l2555 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -9720 0 0 {name=l2556 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -9760 2 1 {name=l2557 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -9780 2 1 {name=l2558 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -9900 2 0 {name=l2559 lab=vdda1}
C {devices/lab_pin.sym} 2030 -9920 2 0 {name=l2561 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -9340 2 0 {name=r2119}
C {devices/bus_connect_nolab.sym} 1460 -9360 2 0 {name=r2120}
C {devices/bus_connect_nolab.sym} 1460 -9380 2 0 {name=r2121}
C {devices/bus_connect_nolab.sym} 1460 -9400 2 0 {name=r2122}
C {devices/bus_connect_nolab.sym} 1460 -9420 2 0 {name=r2123}
C {devices/bus_connect_nolab.sym} 1460 -9440 2 0 {name=r2124}
C {devices/bus_connect_nolab.sym} 1460 -9460 2 0 {name=r2125}
C {devices/bus_connect_nolab.sym} 1460 -9480 2 0 {name=r2126}
C {devices/bus_connect_nolab.sym} 1460 -9500 2 0 {name=r2127}
C {devices/bus_connect_nolab.sym} 1460 -9520 2 0 {name=r2128}
C {devices/bus_connect_nolab.sym} 1460 -9560 2 0 {name=r2129}
C {devices/bus_connect_nolab.sym} 1460 -9540 2 0 {name=r2130}
C {devices/bus_connect_nolab.sym} 1460 -9600 2 0 {name=r2131}
C {devices/bus_connect_nolab.sym} 1460 -9580 2 0 {name=r2132}
C {devices/bus_connect_nolab.sym} 1460 -9640 2 0 {name=r2133}
C {devices/bus_connect_nolab.sym} 1460 -9620 2 0 {name=r2134}
C {devices/lab_wire.sym} 1510 -9340 0 0 {name=l2562 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -9360 0 0 {name=l2563 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -9380 0 0 {name=l2564 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -9380 0 0 {name=l2565 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -9400 0 0 {name=l2566 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -9420 0 0 {name=l2567 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -9440 0 0 {name=l2568 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -9460 0 0 {name=l2569 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -9480 0 0 {name=l2570 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -9500 0 0 {name=l2571 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -9520 0 0 {name=l2572 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -9560 0 0 {name=l2573 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -9540 0 0 {name=l2574 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -9580 0 0 {name=l2575 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -9600 0 0 {name=l2576 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -9620 0 0 {name=l2577 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -9640 0 0 {name=l2578 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -9290 3 0 {name=l2579 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -9340 2 1 {name=r2135}
C {devices/bus_connect_nolab.sym} 2080 -9360 2 1 {name=r2136}
C {devices/bus_connect_nolab.sym} 2080 -9380 2 1 {name=r2137}
C {devices/bus_connect_nolab.sym} 2080 -9400 2 1 {name=r2138}
C {devices/bus_connect_nolab.sym} 2080 -9420 2 1 {name=r2139}
C {devices/bus_connect_nolab.sym} 2080 -9440 2 1 {name=r2140}
C {devices/bus_connect_nolab.sym} 2080 -9460 2 1 {name=r2141}
C {devices/bus_connect_nolab.sym} 2080 -9480 2 1 {name=r2142}
C {devices/bus_connect_nolab.sym} 2080 -9500 2 1 {name=r2143}
C {devices/bus_connect_nolab.sym} 2080 -9520 2 1 {name=r2144}
C {devices/bus_connect_nolab.sym} 2080 -9540 2 1 {name=r2145}
C {devices/bus_connect_nolab.sym} 2080 -9560 2 1 {name=r2146}
C {devices/bus_connect_nolab.sym} 2080 -9580 2 1 {name=r2147}
C {devices/bus_connect_nolab.sym} 2080 -9600 2 1 {name=r2148}
C {devices/bus_connect_nolab.sym} 2080 -9620 2 1 {name=r2149}
C {devices/bus_connect_nolab.sym} 2080 -9640 2 1 {name=r2150}
C {devices/lab_pin.sym} 2090 -9290 3 0 {name=l2580 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -9640 0 1 {name=l2581 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -9620 0 1 {name=l2582 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -9600 0 1 {name=l2583 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -9580 0 1 {name=l2584 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -9560 0 1 {name=l2585 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -9540 0 1 {name=l2586 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -9520 0 1 {name=l2587 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -9500 0 1 {name=l2588 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -9480 0 1 {name=l2589 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -9460 0 1 {name=l2590 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -9440 0 1 {name=l2591 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -9420 0 1 {name=l2592 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -9400 0 1 {name=l2593 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -9380 0 1 {name=l2594 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -9360 0 1 {name=l2595 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -9340 0 1 {name=l2596 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -8670 2 0 {name=r2151}
C {devices/bus_connect_nolab.sym} 910 -8690 2 0 {name=r2152}
C {devices/bus_connect_nolab.sym} 910 -8710 2 0 {name=r2153}
C {devices/bus_connect_nolab.sym} 910 -8730 2 0 {name=r2154}
C {devices/bus_connect_nolab.sym} 910 -8750 2 0 {name=r2155}
C {devices/bus_connect_nolab.sym} 910 -8770 2 0 {name=r2156}
C {devices/bus_connect_nolab.sym} 910 -8790 2 0 {name=r2157}
C {devices/bus_connect_nolab.sym} 910 -8810 2 0 {name=r2158}
C {devices/bus_connect_nolab.sym} 910 -8830 2 0 {name=r2159}
C {devices/bus_connect_nolab.sym} 910 -8850 2 0 {name=r2160}
C {devices/bus_connect_nolab.sym} 910 -8870 2 0 {name=r2161}
C {devices/bus_connect_nolab.sym} 910 -8890 2 0 {name=r2162}
C {devices/bus_connect_nolab.sym} 910 -8910 2 0 {name=r2163}
C {devices/bus_connect_nolab.sym} 910 -8930 2 0 {name=r2164}
C {devices/bus_connect_nolab.sym} 910 -8950 2 0 {name=r2165}
C {devices/bus_connect_nolab.sym} 910 -8970 2 0 {name=r2166}
C {devices/lab_pin.sym} 900 -8630 3 0 {name=l2597 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -8670 2 1 {name=r2167}
C {devices/bus_connect_nolab.sym} 1330 -8690 2 1 {name=r2168}
C {devices/bus_connect_nolab.sym} 1330 -8710 2 1 {name=r2169}
C {devices/bus_connect_nolab.sym} 1330 -8730 2 1 {name=r2170}
C {devices/bus_connect_nolab.sym} 1330 -8750 2 1 {name=r2171}
C {devices/bus_connect_nolab.sym} 1330 -8770 2 1 {name=r2172}
C {devices/bus_connect_nolab.sym} 1330 -8790 2 1 {name=r2173}
C {devices/bus_connect_nolab.sym} 1330 -8810 2 1 {name=r2174}
C {devices/bus_connect_nolab.sym} 1330 -8830 2 1 {name=r2175}
C {devices/bus_connect_nolab.sym} 1330 -8850 2 1 {name=r2176}
C {devices/bus_connect_nolab.sym} 1330 -8870 2 1 {name=r2177}
C {devices/bus_connect_nolab.sym} 1330 -8890 2 1 {name=r2178}
C {devices/bus_connect_nolab.sym} 1330 -8910 2 1 {name=r2179}
C {devices/bus_connect_nolab.sym} 1330 -8930 2 1 {name=r2180}
C {devices/bus_connect_nolab.sym} 1330 -8950 2 1 {name=r2181}
C {devices/bus_connect_nolab.sym} 1330 -8970 2 1 {name=r2182}
C {devices/lab_pin.sym} 1340 -8630 1 1 {name=l2598 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -8690 0 0 {name=l2599 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -8710 0 0 {name=l2600 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -8730 0 0 {name=l2601 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -8750 0 0 {name=l2602 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -8770 0 0 {name=l2603 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -8790 0 0 {name=l2604 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -8810 0 0 {name=l2605 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -8830 0 0 {name=l2606 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -8850 0 0 {name=l2607 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -8890 0 0 {name=l2608 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -8870 0 0 {name=l2609 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -8910 0 0 {name=l2610 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -8930 0 0 {name=l2611 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -8950 0 0 {name=l2612 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -8970 0 0 {name=l2613 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -8670 0 0 {name=l2614 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -8690 0 1 {name=l2615 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -8710 0 1 {name=l2616 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -8730 0 1 {name=l2617 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -8750 0 1 {name=l2618 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -8770 0 1 {name=l2619 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -8790 0 1 {name=l2620 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -8810 0 1 {name=l2621 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -8830 0 1 {name=l2622 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -8850 0 1 {name=l2623 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -8890 0 1 {name=l2624 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -8870 0 1 {name=l2625 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -8910 0 1 {name=l2626 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -8930 0 1 {name=l2627 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -8950 0 1 {name=l2628 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -8970 0 1 {name=l2629 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -8670 0 1 {name=l2630 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -8660 2 0 {name=r2183}
C {devices/bus_connect_nolab.sym} 1610 -8680 2 0 {name=r2184}
C {devices/bus_connect_nolab.sym} 1610 -8700 2 0 {name=r2185}
C {devices/bus_connect_nolab.sym} 1610 -8720 2 0 {name=r2186}
C {devices/bus_connect_nolab.sym} 1610 -8740 2 0 {name=r2187}
C {devices/bus_connect_nolab.sym} 1610 -8760 2 0 {name=r2188}
C {devices/bus_connect_nolab.sym} 1610 -8780 2 0 {name=r2189}
C {devices/bus_connect_nolab.sym} 1610 -8800 2 0 {name=r2190}
C {devices/bus_connect_nolab.sym} 1610 -8820 2 0 {name=r2191}
C {devices/bus_connect_nolab.sym} 1610 -8840 2 0 {name=r2192}
C {devices/bus_connect_nolab.sym} 1610 -8860 2 0 {name=r2193}
C {devices/bus_connect_nolab.sym} 1610 -8880 2 0 {name=r2194}
C {devices/bus_connect_nolab.sym} 1610 -8900 2 0 {name=r2195}
C {devices/bus_connect_nolab.sym} 1610 -8920 2 0 {name=r2196}
C {devices/bus_connect_nolab.sym} 1610 -8940 2 0 {name=r2197}
C {devices/bus_connect_nolab.sym} 1610 -8960 2 0 {name=r2198}
C {devices/lab_pin.sym} 1600 -8620 3 0 {name=l2631 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -8660 2 1 {name=r2199}
C {devices/bus_connect_nolab.sym} 2030 -8680 2 1 {name=r2200}
C {devices/bus_connect_nolab.sym} 2030 -8700 2 1 {name=r2201}
C {devices/bus_connect_nolab.sym} 2030 -8720 2 1 {name=r2202}
C {devices/bus_connect_nolab.sym} 2030 -8740 2 1 {name=r2203}
C {devices/bus_connect_nolab.sym} 2030 -8760 2 1 {name=r2204}
C {devices/bus_connect_nolab.sym} 2030 -8780 2 1 {name=r2205}
C {devices/bus_connect_nolab.sym} 2030 -8800 2 1 {name=r2206}
C {devices/bus_connect_nolab.sym} 2030 -8820 2 1 {name=r2207}
C {devices/bus_connect_nolab.sym} 2030 -8840 2 1 {name=r2208}
C {devices/bus_connect_nolab.sym} 2030 -8860 2 1 {name=r2209}
C {devices/bus_connect_nolab.sym} 2030 -8880 2 1 {name=r2210}
C {devices/bus_connect_nolab.sym} 2030 -8900 2 1 {name=r2211}
C {devices/bus_connect_nolab.sym} 2030 -8920 2 1 {name=r2212}
C {devices/bus_connect_nolab.sym} 2030 -8940 2 1 {name=r2213}
C {devices/bus_connect_nolab.sym} 2030 -8960 2 1 {name=r2214}
C {devices/lab_pin.sym} 2040 -8620 1 1 {name=l2632 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -8680 0 0 {name=l2633 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -8700 0 0 {name=l2634 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -8720 0 0 {name=l2635 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -8740 0 0 {name=l2636 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -8760 0 0 {name=l2637 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -8780 0 0 {name=l2638 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -8800 0 0 {name=l2639 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -8820 0 0 {name=l2640 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -8840 0 0 {name=l2641 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -8880 0 0 {name=l2642 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -8860 0 0 {name=l2643 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -8900 0 0 {name=l2644 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -8920 0 0 {name=l2645 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -8940 0 0 {name=l2646 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -8960 0 0 {name=l2647 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -8660 0 0 {name=l2648 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -8680 0 1 {name=l2649 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -8700 0 1 {name=l2650 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -8720 0 1 {name=l2651 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -8740 0 1 {name=l2652 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -8760 0 1 {name=l2653 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -8780 0 1 {name=l2654 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -8800 0 1 {name=l2655 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -8820 0 1 {name=l2656 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -8840 0 1 {name=l2657 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -8880 0 1 {name=l2658 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -8860 0 1 {name=l2659 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -8900 0 1 {name=l2660 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -8920 0 1 {name=l2661 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -8940 0 1 {name=l2662 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -8960 0 1 {name=l2663 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -8660 0 1 {name=l2664 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -9350 2 0 {name=r2215}
C {devices/bus_connect_nolab.sym} 2190 -9370 2 0 {name=r2216}
C {devices/bus_connect_nolab.sym} 2190 -9390 2 0 {name=r2217}
C {devices/bus_connect_nolab.sym} 2190 -9410 2 0 {name=r2218}
C {devices/bus_connect_nolab.sym} 2190 -9430 2 0 {name=r2219}
C {devices/bus_connect_nolab.sym} 2190 -9450 2 0 {name=r2220}
C {devices/bus_connect_nolab.sym} 2190 -9470 2 0 {name=r2221}
C {devices/bus_connect_nolab.sym} 2190 -9490 2 0 {name=r2222}
C {devices/bus_connect_nolab.sym} 2190 -9510 2 0 {name=r2223}
C {devices/bus_connect_nolab.sym} 2190 -9530 2 0 {name=r2224}
C {devices/bus_connect_nolab.sym} 2190 -9570 2 0 {name=r2225}
C {devices/bus_connect_nolab.sym} 2190 -9550 2 0 {name=r2226}
C {devices/bus_connect_nolab.sym} 2190 -9610 2 0 {name=r2227}
C {devices/bus_connect_nolab.sym} 2190 -9590 2 0 {name=r2228}
C {devices/bus_connect_nolab.sym} 2190 -9650 2 0 {name=r2229}
C {devices/bus_connect_nolab.sym} 2190 -9630 2 0 {name=r2230}
C {devices/lab_wire.sym} 2240 -9350 0 0 {name=l2665 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -9370 0 0 {name=l2666 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -9390 0 0 {name=l2667 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -9390 0 0 {name=l2668 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -9410 0 0 {name=l2669 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -9430 0 0 {name=l2670 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -9450 0 0 {name=l2671 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -9470 0 0 {name=l2672 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -9490 0 0 {name=l2673 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -9510 0 0 {name=l2674 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -9530 0 0 {name=l2675 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -9570 0 0 {name=l2676 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -9550 0 0 {name=l2677 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -9590 0 0 {name=l2678 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -9610 0 0 {name=l2679 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -9630 0 0 {name=l2680 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -9650 0 0 {name=l2681 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -9300 3 0 {name=l2682 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -9350 2 1 {name=r2231}
C {devices/bus_connect_nolab.sym} 2810 -9370 2 1 {name=r2232}
C {devices/bus_connect_nolab.sym} 2810 -9390 2 1 {name=r2233}
C {devices/bus_connect_nolab.sym} 2810 -9410 2 1 {name=r2234}
C {devices/bus_connect_nolab.sym} 2810 -9430 2 1 {name=r2235}
C {devices/bus_connect_nolab.sym} 2810 -9450 2 1 {name=r2236}
C {devices/bus_connect_nolab.sym} 2810 -9470 2 1 {name=r2237}
C {devices/bus_connect_nolab.sym} 2810 -9490 2 1 {name=r2238}
C {devices/bus_connect_nolab.sym} 2810 -9510 2 1 {name=r2239}
C {devices/bus_connect_nolab.sym} 2810 -9530 2 1 {name=r2240}
C {devices/bus_connect_nolab.sym} 2810 -9550 2 1 {name=r2241}
C {devices/bus_connect_nolab.sym} 2810 -9570 2 1 {name=r2242}
C {devices/bus_connect_nolab.sym} 2810 -9590 2 1 {name=r2243}
C {devices/bus_connect_nolab.sym} 2810 -9610 2 1 {name=r2244}
C {devices/bus_connect_nolab.sym} 2810 -9630 2 1 {name=r2245}
C {devices/bus_connect_nolab.sym} 2810 -9650 2 1 {name=r2246}
C {devices/lab_pin.sym} 2820 -9300 3 0 {name=l2683 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -9650 0 1 {name=l2684 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -9630 0 1 {name=l2685 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -9610 0 1 {name=l2686 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -9590 0 1 {name=l2687 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -9570 0 1 {name=l2688 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -9550 0 1 {name=l2689 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -9530 0 1 {name=l2690 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -9510 0 1 {name=l2691 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -9490 0 1 {name=l2692 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -9470 0 1 {name=l2693 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -9450 0 1 {name=l2694 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -9430 0 1 {name=l2695 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -9410 0 1 {name=l2696 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -9390 0 1 {name=l2697 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -9370 0 1 {name=l2698 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -9350 0 1 {name=l2699 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -8670 2 0 {name=r2247}
C {devices/bus_connect_nolab.sym} 2340 -8690 2 0 {name=r2248}
C {devices/bus_connect_nolab.sym} 2340 -8710 2 0 {name=r2249}
C {devices/bus_connect_nolab.sym} 2340 -8730 2 0 {name=r2250}
C {devices/bus_connect_nolab.sym} 2340 -8750 2 0 {name=r2251}
C {devices/bus_connect_nolab.sym} 2340 -8770 2 0 {name=r2252}
C {devices/bus_connect_nolab.sym} 2340 -8790 2 0 {name=r2253}
C {devices/bus_connect_nolab.sym} 2340 -8810 2 0 {name=r2254}
C {devices/bus_connect_nolab.sym} 2340 -8830 2 0 {name=r2255}
C {devices/bus_connect_nolab.sym} 2340 -8850 2 0 {name=r2256}
C {devices/bus_connect_nolab.sym} 2340 -8870 2 0 {name=r2257}
C {devices/bus_connect_nolab.sym} 2340 -8890 2 0 {name=r2258}
C {devices/bus_connect_nolab.sym} 2340 -8910 2 0 {name=r2259}
C {devices/bus_connect_nolab.sym} 2340 -8930 2 0 {name=r2260}
C {devices/bus_connect_nolab.sym} 2340 -8950 2 0 {name=r2261}
C {devices/bus_connect_nolab.sym} 2340 -8970 2 0 {name=r2262}
C {devices/lab_pin.sym} 2330 -8630 3 0 {name=l2700 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -8670 2 1 {name=r2263}
C {devices/bus_connect_nolab.sym} 2760 -8690 2 1 {name=r2264}
C {devices/bus_connect_nolab.sym} 2760 -8710 2 1 {name=r2265}
C {devices/bus_connect_nolab.sym} 2760 -8730 2 1 {name=r2266}
C {devices/bus_connect_nolab.sym} 2760 -8750 2 1 {name=r2267}
C {devices/bus_connect_nolab.sym} 2760 -8770 2 1 {name=r2268}
C {devices/bus_connect_nolab.sym} 2760 -8790 2 1 {name=r2269}
C {devices/bus_connect_nolab.sym} 2760 -8810 2 1 {name=r2270}
C {devices/bus_connect_nolab.sym} 2760 -8830 2 1 {name=r2271}
C {devices/bus_connect_nolab.sym} 2760 -8850 2 1 {name=r2272}
C {devices/bus_connect_nolab.sym} 2760 -8870 2 1 {name=r2273}
C {devices/bus_connect_nolab.sym} 2760 -8890 2 1 {name=r2274}
C {devices/bus_connect_nolab.sym} 2760 -8910 2 1 {name=r2275}
C {devices/bus_connect_nolab.sym} 2760 -8930 2 1 {name=r2276}
C {devices/bus_connect_nolab.sym} 2760 -8950 2 1 {name=r2277}
C {devices/bus_connect_nolab.sym} 2760 -8970 2 1 {name=r2278}
C {devices/lab_pin.sym} 2770 -8630 1 1 {name=l2701 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -8690 0 0 {name=l2702 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -8710 0 0 {name=l2703 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -8730 0 0 {name=l2704 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -8750 0 0 {name=l2705 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -8770 0 0 {name=l2706 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -8790 0 0 {name=l2707 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -8810 0 0 {name=l2708 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -8830 0 0 {name=l2709 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -8850 0 0 {name=l2710 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -8890 0 0 {name=l2711 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -8870 0 0 {name=l2712 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -8910 0 0 {name=l2713 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -8930 0 0 {name=l2714 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -8950 0 0 {name=l2715 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -8970 0 0 {name=l2716 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -8670 0 0 {name=l2717 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -8690 0 1 {name=l2718 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -8710 0 1 {name=l2719 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -8730 0 1 {name=l2720 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -8750 0 1 {name=l2721 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -8770 0 1 {name=l2722 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -8790 0 1 {name=l2723 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -8810 0 1 {name=l2724 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -8830 0 1 {name=l2725 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -8850 0 1 {name=l2726 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -8890 0 1 {name=l2727 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -8870 0 1 {name=l2728 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -8910 0 1 {name=l2729 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -8930 0 1 {name=l2730 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -8950 0 1 {name=l2731 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -8970 0 1 {name=l2732 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -8670 0 1 {name=l2733 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -9340 2 0 {name=r2279}
C {devices/bus_connect_nolab.sym} 2890 -9360 2 0 {name=r2280}
C {devices/bus_connect_nolab.sym} 2890 -9380 2 0 {name=r2281}
C {devices/bus_connect_nolab.sym} 2890 -9400 2 0 {name=r2282}
C {devices/bus_connect_nolab.sym} 2890 -9420 2 0 {name=r2283}
C {devices/bus_connect_nolab.sym} 2890 -9440 2 0 {name=r2284}
C {devices/bus_connect_nolab.sym} 2890 -9460 2 0 {name=r2285}
C {devices/bus_connect_nolab.sym} 2890 -9480 2 0 {name=r2286}
C {devices/bus_connect_nolab.sym} 2890 -9500 2 0 {name=r2287}
C {devices/bus_connect_nolab.sym} 2890 -9520 2 0 {name=r2288}
C {devices/bus_connect_nolab.sym} 2890 -9560 2 0 {name=r2289}
C {devices/bus_connect_nolab.sym} 2890 -9540 2 0 {name=r2290}
C {devices/bus_connect_nolab.sym} 2890 -9600 2 0 {name=r2291}
C {devices/bus_connect_nolab.sym} 2890 -9580 2 0 {name=r2292}
C {devices/bus_connect_nolab.sym} 2890 -9640 2 0 {name=r2293}
C {devices/bus_connect_nolab.sym} 2890 -9620 2 0 {name=r2294}
C {devices/lab_wire.sym} 2940 -9340 0 0 {name=l2734 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -9360 0 0 {name=l2735 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -9380 0 0 {name=l2736 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -9380 0 0 {name=l2737 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -9400 0 0 {name=l2738 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -9420 0 0 {name=l2739 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -9440 0 0 {name=l2740 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -9460 0 0 {name=l2741 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -9480 0 0 {name=l2742 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -9500 0 0 {name=l2743 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -9520 0 0 {name=l2744 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -9560 0 0 {name=l2745 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -9540 0 0 {name=l2746 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -9580 0 0 {name=l2747 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -9600 0 0 {name=l2748 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -9620 0 0 {name=l2749 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -9640 0 0 {name=l2750 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -9290 3 0 {name=l2751 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -9340 2 1 {name=r2295}
C {devices/bus_connect_nolab.sym} 3510 -9360 2 1 {name=r2296}
C {devices/bus_connect_nolab.sym} 3510 -9380 2 1 {name=r2297}
C {devices/bus_connect_nolab.sym} 3510 -9400 2 1 {name=r2298}
C {devices/bus_connect_nolab.sym} 3510 -9420 2 1 {name=r2299}
C {devices/bus_connect_nolab.sym} 3510 -9440 2 1 {name=r2300}
C {devices/bus_connect_nolab.sym} 3510 -9460 2 1 {name=r2301}
C {devices/bus_connect_nolab.sym} 3510 -9480 2 1 {name=r2302}
C {devices/bus_connect_nolab.sym} 3510 -9500 2 1 {name=r2303}
C {devices/bus_connect_nolab.sym} 3510 -9520 2 1 {name=r2304}
C {devices/bus_connect_nolab.sym} 3510 -9540 2 1 {name=r2305}
C {devices/bus_connect_nolab.sym} 3510 -9560 2 1 {name=r2306}
C {devices/bus_connect_nolab.sym} 3510 -9580 2 1 {name=r2307}
C {devices/bus_connect_nolab.sym} 3510 -9600 2 1 {name=r2308}
C {devices/bus_connect_nolab.sym} 3510 -9620 2 1 {name=r2309}
C {devices/bus_connect_nolab.sym} 3510 -9640 2 1 {name=r2310}
C {devices/lab_pin.sym} 3520 -9290 3 0 {name=l2752 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -9640 0 1 {name=l2753 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -9620 0 1 {name=l2754 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -9600 0 1 {name=l2755 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -9580 0 1 {name=l2756 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -9560 0 1 {name=l2757 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -9540 0 1 {name=l2758 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -9520 0 1 {name=l2759 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -9500 0 1 {name=l2760 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -9480 0 1 {name=l2761 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -9460 0 1 {name=l2762 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -9440 0 1 {name=l2763 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -9420 0 1 {name=l2764 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -9400 0 1 {name=l2765 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -9380 0 1 {name=l2766 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -9360 0 1 {name=l2767 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -9340 0 1 {name=l2768 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -8660 2 0 {name=r2311}
C {devices/bus_connect_nolab.sym} 3040 -8680 2 0 {name=r2312}
C {devices/bus_connect_nolab.sym} 3040 -8700 2 0 {name=r2313}
C {devices/bus_connect_nolab.sym} 3040 -8720 2 0 {name=r2314}
C {devices/bus_connect_nolab.sym} 3040 -8740 2 0 {name=r2315}
C {devices/bus_connect_nolab.sym} 3040 -8760 2 0 {name=r2316}
C {devices/bus_connect_nolab.sym} 3040 -8780 2 0 {name=r2317}
C {devices/bus_connect_nolab.sym} 3040 -8800 2 0 {name=r2318}
C {devices/bus_connect_nolab.sym} 3040 -8820 2 0 {name=r2319}
C {devices/bus_connect_nolab.sym} 3040 -8840 2 0 {name=r2320}
C {devices/bus_connect_nolab.sym} 3040 -8860 2 0 {name=r2321}
C {devices/bus_connect_nolab.sym} 3040 -8880 2 0 {name=r2322}
C {devices/bus_connect_nolab.sym} 3040 -8900 2 0 {name=r2323}
C {devices/bus_connect_nolab.sym} 3040 -8920 2 0 {name=r2324}
C {devices/bus_connect_nolab.sym} 3040 -8940 2 0 {name=r2325}
C {devices/bus_connect_nolab.sym} 3040 -8960 2 0 {name=r2326}
C {devices/lab_pin.sym} 3030 -8620 3 0 {name=l2769 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -8660 2 1 {name=r2327}
C {devices/bus_connect_nolab.sym} 3460 -8680 2 1 {name=r2328}
C {devices/bus_connect_nolab.sym} 3460 -8700 2 1 {name=r2329}
C {devices/bus_connect_nolab.sym} 3460 -8720 2 1 {name=r2330}
C {devices/bus_connect_nolab.sym} 3460 -8740 2 1 {name=r2331}
C {devices/bus_connect_nolab.sym} 3460 -8760 2 1 {name=r2332}
C {devices/bus_connect_nolab.sym} 3460 -8780 2 1 {name=r2333}
C {devices/bus_connect_nolab.sym} 3460 -8800 2 1 {name=r2334}
C {devices/bus_connect_nolab.sym} 3460 -8820 2 1 {name=r2335}
C {devices/bus_connect_nolab.sym} 3460 -8840 2 1 {name=r2336}
C {devices/bus_connect_nolab.sym} 3460 -8860 2 1 {name=r2337}
C {devices/bus_connect_nolab.sym} 3460 -8880 2 1 {name=r2338}
C {devices/bus_connect_nolab.sym} 3460 -8900 2 1 {name=r2339}
C {devices/bus_connect_nolab.sym} 3460 -8920 2 1 {name=r2340}
C {devices/bus_connect_nolab.sym} 3460 -8940 2 1 {name=r2341}
C {devices/bus_connect_nolab.sym} 3460 -8960 2 1 {name=r2342}
C {devices/lab_pin.sym} 3470 -8620 1 1 {name=l2770 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -8680 0 0 {name=l2771 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -8700 0 0 {name=l2772 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -8720 0 0 {name=l2773 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -8740 0 0 {name=l2774 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -8760 0 0 {name=l2775 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -8780 0 0 {name=l2776 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -8800 0 0 {name=l2777 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -8820 0 0 {name=l2778 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -8840 0 0 {name=l2779 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -8880 0 0 {name=l2780 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -8860 0 0 {name=l2781 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -8900 0 0 {name=l2782 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -8920 0 0 {name=l2783 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -8940 0 0 {name=l2784 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -8960 0 0 {name=l2785 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -8660 0 0 {name=l2786 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -8680 0 1 {name=l2787 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -8700 0 1 {name=l2788 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -8720 0 1 {name=l2789 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -8740 0 1 {name=l2790 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -8760 0 1 {name=l2791 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -8780 0 1 {name=l2792 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -8800 0 1 {name=l2793 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -8820 0 1 {name=l2794 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -8840 0 1 {name=l2795 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -8880 0 1 {name=l2796 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -8860 0 1 {name=l2797 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -8900 0 1 {name=l2798 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -8920 0 1 {name=l2799 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -8940 0 1 {name=l2800 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -8960 0 1 {name=l2801 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -8660 0 1 {name=l2802 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -9340 2 0 {name=r2343}
C {devices/bus_connect_nolab.sym} 3600 -9360 2 0 {name=r2344}
C {devices/bus_connect_nolab.sym} 3600 -9380 2 0 {name=r2345}
C {devices/bus_connect_nolab.sym} 3600 -9400 2 0 {name=r2346}
C {devices/bus_connect_nolab.sym} 3600 -9420 2 0 {name=r2347}
C {devices/bus_connect_nolab.sym} 3600 -9440 2 0 {name=r2348}
C {devices/bus_connect_nolab.sym} 3600 -9460 2 0 {name=r2349}
C {devices/bus_connect_nolab.sym} 3600 -9480 2 0 {name=r2350}
C {devices/bus_connect_nolab.sym} 3600 -9500 2 0 {name=r2351}
C {devices/bus_connect_nolab.sym} 3600 -9520 2 0 {name=r2352}
C {devices/bus_connect_nolab.sym} 3600 -9560 2 0 {name=r2353}
C {devices/bus_connect_nolab.sym} 3600 -9540 2 0 {name=r2354}
C {devices/bus_connect_nolab.sym} 3600 -9600 2 0 {name=r2355}
C {devices/bus_connect_nolab.sym} 3600 -9580 2 0 {name=r2356}
C {devices/bus_connect_nolab.sym} 3600 -9640 2 0 {name=r2357}
C {devices/bus_connect_nolab.sym} 3600 -9620 2 0 {name=r2358}
C {devices/lab_wire.sym} 3650 -9340 0 0 {name=l2803 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -9360 0 0 {name=l2804 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -9380 0 0 {name=l2805 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -9380 0 0 {name=l2806 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -9400 0 0 {name=l2807 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -9420 0 0 {name=l2808 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -9440 0 0 {name=l2809 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -9460 0 0 {name=l2810 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -9480 0 0 {name=l2811 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -9500 0 0 {name=l2812 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -9520 0 0 {name=l2813 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -9560 0 0 {name=l2814 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -9540 0 0 {name=l2815 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -9580 0 0 {name=l2816 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -9600 0 0 {name=l2817 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -9620 0 0 {name=l2818 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -9640 0 0 {name=l2819 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -9290 3 0 {name=l2820 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -9340 2 1 {name=r2359}
C {devices/bus_connect_nolab.sym} 4220 -9360 2 1 {name=r2360}
C {devices/bus_connect_nolab.sym} 4220 -9380 2 1 {name=r2361}
C {devices/bus_connect_nolab.sym} 4220 -9400 2 1 {name=r2362}
C {devices/bus_connect_nolab.sym} 4220 -9420 2 1 {name=r2363}
C {devices/bus_connect_nolab.sym} 4220 -9440 2 1 {name=r2364}
C {devices/bus_connect_nolab.sym} 4220 -9460 2 1 {name=r2365}
C {devices/bus_connect_nolab.sym} 4220 -9480 2 1 {name=r2366}
C {devices/bus_connect_nolab.sym} 4220 -9500 2 1 {name=r2367}
C {devices/bus_connect_nolab.sym} 4220 -9520 2 1 {name=r2368}
C {devices/bus_connect_nolab.sym} 4220 -9540 2 1 {name=r2369}
C {devices/bus_connect_nolab.sym} 4220 -9560 2 1 {name=r2370}
C {devices/bus_connect_nolab.sym} 4220 -9580 2 1 {name=r2371}
C {devices/bus_connect_nolab.sym} 4220 -9600 2 1 {name=r2372}
C {devices/bus_connect_nolab.sym} 4220 -9620 2 1 {name=r2373}
C {devices/bus_connect_nolab.sym} 4220 -9640 2 1 {name=r2374}
C {devices/lab_pin.sym} 4230 -9290 3 0 {name=l2821 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -9640 0 1 {name=l2822 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -9620 0 1 {name=l2823 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -9600 0 1 {name=l2824 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -9580 0 1 {name=l2825 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -9560 0 1 {name=l2826 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -9540 0 1 {name=l2827 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -9520 0 1 {name=l2828 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -9500 0 1 {name=l2829 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -9480 0 1 {name=l2830 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -9460 0 1 {name=l2831 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -9440 0 1 {name=l2832 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -9420 0 1 {name=l2833 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -9400 0 1 {name=l2834 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -9380 0 1 {name=l2835 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -9360 0 1 {name=l2836 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -9340 0 1 {name=l2837 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -8660 2 0 {name=r2375}
C {devices/bus_connect_nolab.sym} 3750 -8680 2 0 {name=r2376}
C {devices/bus_connect_nolab.sym} 3750 -8700 2 0 {name=r2377}
C {devices/bus_connect_nolab.sym} 3750 -8720 2 0 {name=r2378}
C {devices/bus_connect_nolab.sym} 3750 -8740 2 0 {name=r2379}
C {devices/bus_connect_nolab.sym} 3750 -8760 2 0 {name=r2380}
C {devices/bus_connect_nolab.sym} 3750 -8780 2 0 {name=r2381}
C {devices/bus_connect_nolab.sym} 3750 -8800 2 0 {name=r2382}
C {devices/bus_connect_nolab.sym} 3750 -8820 2 0 {name=r2383}
C {devices/bus_connect_nolab.sym} 3750 -8840 2 0 {name=r2384}
C {devices/bus_connect_nolab.sym} 3750 -8860 2 0 {name=r2385}
C {devices/bus_connect_nolab.sym} 3750 -8880 2 0 {name=r2386}
C {devices/bus_connect_nolab.sym} 3750 -8900 2 0 {name=r2387}
C {devices/bus_connect_nolab.sym} 3750 -8920 2 0 {name=r2388}
C {devices/bus_connect_nolab.sym} 3750 -8940 2 0 {name=r2389}
C {devices/bus_connect_nolab.sym} 3750 -8960 2 0 {name=r2390}
C {devices/lab_pin.sym} 3740 -8620 3 0 {name=l2838 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -8660 2 1 {name=r2391}
C {devices/bus_connect_nolab.sym} 4170 -8680 2 1 {name=r2392}
C {devices/bus_connect_nolab.sym} 4170 -8700 2 1 {name=r2393}
C {devices/bus_connect_nolab.sym} 4170 -8720 2 1 {name=r2394}
C {devices/bus_connect_nolab.sym} 4170 -8740 2 1 {name=r2395}
C {devices/bus_connect_nolab.sym} 4170 -8760 2 1 {name=r2396}
C {devices/bus_connect_nolab.sym} 4170 -8780 2 1 {name=r2397}
C {devices/bus_connect_nolab.sym} 4170 -8800 2 1 {name=r2398}
C {devices/bus_connect_nolab.sym} 4170 -8820 2 1 {name=r2399}
C {devices/bus_connect_nolab.sym} 4170 -8840 2 1 {name=r2400}
C {devices/bus_connect_nolab.sym} 4170 -8860 2 1 {name=r2401}
C {devices/bus_connect_nolab.sym} 4170 -8880 2 1 {name=r2402}
C {devices/bus_connect_nolab.sym} 4170 -8900 2 1 {name=r2403}
C {devices/bus_connect_nolab.sym} 4170 -8920 2 1 {name=r2404}
C {devices/bus_connect_nolab.sym} 4170 -8940 2 1 {name=r2405}
C {devices/bus_connect_nolab.sym} 4170 -8960 2 1 {name=r2406}
C {devices/lab_pin.sym} 4180 -8620 1 1 {name=l2839 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -8680 0 0 {name=l2840 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -8700 0 0 {name=l2841 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -8720 0 0 {name=l2842 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -8740 0 0 {name=l2843 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -8760 0 0 {name=l2844 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -8780 0 0 {name=l2845 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -8800 0 0 {name=l2846 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3790 -8820 0 0 {name=l2847 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -8840 0 0 {name=l2848 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -8880 0 0 {name=l2849 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -8860 0 0 {name=l2850 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -8900 0 0 {name=l2851 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -8920 0 0 {name=l2852 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -8940 0 0 {name=l2853 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -8960 0 0 {name=l2854 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -8660 0 0 {name=l2855 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -8680 0 1 {name=l2856 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -8700 0 1 {name=l2857 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -8720 0 1 {name=l2858 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -8740 0 1 {name=l2859 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -8760 0 1 {name=l2860 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -8780 0 1 {name=l2861 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -8800 0 1 {name=l2862 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -8820 0 1 {name=l2863 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -8840 0 1 {name=l2864 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -8880 0 1 {name=l2865 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -8860 0 1 {name=l2866 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -8900 0 1 {name=l2867 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -8920 0 1 {name=l2868 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -8940 0 1 {name=l2869 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -8960 0 1 {name=l2870 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -8660 0 1 {name=l2871 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -9830 2 1 {name=l2872 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -9850 0 0 {name=l2873 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -9950 0 0 {name=l2874 lab=row4_sel}
C {devices/lab_pin.sym} 2340 -9930 0 0 {name=l2875 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -9870 0 0 {name=l2876 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -9910 0 0 {name=l2877 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -9890 0 0 {name=l2878 lab=WR}
C {devices/lab_pin.sym} 2340 -9810 2 1 {name=l2879 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -9750 0 0 {name=l2880 lab=Vref}
C {devices/lab_pin.sym} 2340 -9710 0 0 {name=l2881 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -9730 0 0 {name=l2882 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -9770 2 1 {name=l2883 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -9790 2 1 {name=l2884 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -9820 2 1 {name=l2885 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -9840 0 0 {name=l2886 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -9940 0 0 {name=l2887 lab=row4_sel}
C {devices/lab_pin.sym} 3040 -9920 0 0 {name=l2888 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -9860 0 0 {name=l2889 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -9900 0 0 {name=l2890 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -9880 0 0 {name=l2891 lab=WR}
C {devices/lab_pin.sym} 3040 -9800 2 1 {name=l2892 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -9740 0 0 {name=l2893 lab=Vref}
C {devices/lab_pin.sym} 3040 -9700 0 0 {name=l2894 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -9720 0 0 {name=l2895 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -9760 2 1 {name=l2896 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -9780 2 1 {name=l2897 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -9820 2 1 {name=l2898 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -9840 0 0 {name=l2899 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -9940 0 0 {name=l2900 lab=row4_sel}
C {devices/lab_pin.sym} 3750 -9920 0 0 {name=l2901 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -9860 0 0 {name=l2902 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -9900 0 0 {name=l2903 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -9880 0 0 {name=l2904 lab=WR}
C {devices/lab_pin.sym} 3750 -9800 2 1 {name=l2905 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -9740 0 0 {name=l2906 lab=Vref}
C {devices/lab_pin.sym} 3750 -9700 0 0 {name=l2907 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -9720 0 0 {name=l2908 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -9760 2 1 {name=l2909 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -9780 2 1 {name=l2910 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -9830 2 1 {name=l2911 lab=Vrminus}
C {devices/lab_pin.sym} 190 -9850 0 0 {name=l2912 lab=SAMPLE}
C {devices/lab_pin.sym} 190 -9870 0 0 {name=l2913 lab=Vgpr}
C {devices/lab_pin.sym} 190 -9910 0 0 {name=l2914 lab=Vgnr}
C {devices/lab_pin.sym} 190 -9890 0 0 {name=l2915 lab=WR}
C {devices/lab_pin.sym} 190 -9810 2 1 {name=l2916 lab=Vrplus}
C {devices/lab_pin.sym} 190 -9750 0 0 {name=l2917 lab=Vref}
C {devices/lab_pin.sym} 190 -9710 0 0 {name=l2918 lab=Vcplus}
C {devices/lab_pin.sym} 190 -9730 0 0 {name=l2919 lab=Vcminus}
C {devices/lab_pin.sym} 190 -9770 2 1 {name=l2920 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 190 -9790 2 1 {name=l2921 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 610 -9910 2 0 {name=l2922 lab=vdda1}
C {devices/lab_pin.sym} 610 -9930 2 0 {name=l2924 lab=vccd1}
C {devices/lab_pin.sym} 610 -9950 2 0 {name=l2925 lab=latch_high0}
C {devices/lab_pin.sym} 2030 -9940 2 0 {name=l2926 lab=latch_high2}
C {devices/lab_pin.sym} 2760 -9950 2 0 {name=l2927 lab=latch_high3}
C {devices/lab_pin.sym} 3460 -9940 2 0 {name=l2928 lab=latch_high4}
C {devices/lab_pin.sym} 4170 -9940 2 0 {name=l2929 lab=latch_high5}
C {devices/lab_pin.sym} 1330 -9950 2 0 {name=l2930 lab=latch_high1}
C {devices/lab_pin.sym} 190 -12020 0 0 {name=l2931 lab=row5_sel}
C {devices/lab_pin.sym} 190 -12000 0 0 {name=l2932 lab=col0_sel}
C {devices/lab_pin.sym} 910 -11900 2 1 {name=l2933 lab=Vrminus}
C {devices/lab_pin.sym} 910 -11920 0 0 {name=l2934 lab=SAMPLE}
C {devices/lab_pin.sym} 2760 -11980 2 0 {name=l2935 lab=vdda1}
C {devices/lab_pin.sym} 2760 -12000 2 0 {name=l2937 lab=vccd1}
C {devices/lab_pin.sym} 3460 -11970 2 0 {name=l2938 lab=vdda1}
C {devices/lab_pin.sym} 3460 -11990 2 0 {name=l2940 lab=vccd1}
C {devices/lab_pin.sym} 4170 -11970 2 0 {name=l2941 lab=vdda1}
C {devices/lab_pin.sym} 4170 -11990 2 0 {name=l2943 lab=vccd1}
C {devices/lab_wire.sym} 130 -11380 0 0 {name=l2944 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -11360 0 0 {name=l2945 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -11340 0 0 {name=l2946 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -11320 0 0 {name=l2947 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -11300 0 0 {name=l2948 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -11280 0 0 {name=l2949 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -11260 0 0 {name=l2950 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -11240 0 0 {name=l2951 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -11220 0 0 {name=l2952 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -11200 0 0 {name=l2953 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -11180 0 0 {name=l2954 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -11160 0 0 {name=l2955 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -11140 0 0 {name=l2956 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -11120 0 0 {name=l2957 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -11100 0 0 {name=l2958 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -11080 0 0 {name=l2959 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -11040 3 0 {name=l2960 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -11080 2 0 {name=r2407}
C {devices/bus_connect_nolab.sym} 70 -11100 2 0 {name=r2408}
C {devices/bus_connect_nolab.sym} 70 -11120 2 0 {name=r2409}
C {devices/bus_connect_nolab.sym} 70 -11140 2 0 {name=r2410}
C {devices/bus_connect_nolab.sym} 70 -11160 2 0 {name=r2411}
C {devices/bus_connect_nolab.sym} 70 -11180 2 0 {name=r2412}
C {devices/bus_connect_nolab.sym} 70 -11200 2 0 {name=r2413}
C {devices/bus_connect_nolab.sym} 70 -11220 2 0 {name=r2414}
C {devices/bus_connect_nolab.sym} 70 -11240 2 0 {name=r2415}
C {devices/bus_connect_nolab.sym} 70 -11260 2 0 {name=r2416}
C {devices/bus_connect_nolab.sym} 70 -11280 2 0 {name=r2417}
C {devices/bus_connect_nolab.sym} 70 -11300 2 0 {name=r2418}
C {devices/bus_connect_nolab.sym} 70 -11320 2 0 {name=r2419}
C {devices/bus_connect_nolab.sym} 70 -11340 2 0 {name=r2420}
C {devices/bus_connect_nolab.sym} 70 -11360 2 0 {name=r2421}
C {devices/bus_connect_nolab.sym} 70 -11380 2 0 {name=r2422}
C {devices/lab_wire.sym} 850 -11380 0 0 {name=l2961 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -11360 0 0 {name=l2962 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -11340 0 0 {name=l2963 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -11320 0 0 {name=l2964 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -11300 0 0 {name=l2965 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -11280 0 0 {name=l2966 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -11260 0 0 {name=l2967 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -11240 0 0 {name=l2968 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -11220 0 0 {name=l2969 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -11200 0 0 {name=l2970 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -11180 0 0 {name=l2971 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -11160 0 0 {name=l2972 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -11140 0 0 {name=l2973 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -11120 0 0 {name=l2974 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -11100 0 0 {name=l2975 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -11040 3 0 {name=l2976 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -11080 2 0 {name=r2423}
C {devices/bus_connect_nolab.sym} 790 -11100 2 0 {name=r2424}
C {devices/bus_connect_nolab.sym} 790 -11120 2 0 {name=r2425}
C {devices/bus_connect_nolab.sym} 790 -11140 2 0 {name=r2426}
C {devices/bus_connect_nolab.sym} 790 -11160 2 0 {name=r2427}
C {devices/bus_connect_nolab.sym} 790 -11180 2 0 {name=r2428}
C {devices/bus_connect_nolab.sym} 790 -11200 2 0 {name=r2429}
C {devices/bus_connect_nolab.sym} 790 -11220 2 0 {name=r2430}
C {devices/bus_connect_nolab.sym} 790 -11240 2 0 {name=r2431}
C {devices/bus_connect_nolab.sym} 790 -11260 2 0 {name=r2432}
C {devices/bus_connect_nolab.sym} 790 -11280 2 0 {name=r2433}
C {devices/bus_connect_nolab.sym} 790 -11300 2 0 {name=r2434}
C {devices/bus_connect_nolab.sym} 790 -11320 2 0 {name=r2435}
C {devices/bus_connect_nolab.sym} 790 -11340 2 0 {name=r2436}
C {devices/bus_connect_nolab.sym} 790 -11360 2 0 {name=r2437}
C {devices/bus_connect_nolab.sym} 790 -11380 2 0 {name=r2438}
C {devices/lab_wire.sym} 850 -11080 0 0 {name=l2977 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -11370 0 0 {name=l2978 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -11350 0 0 {name=l2979 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -11330 0 0 {name=l2980 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -11310 0 0 {name=l2981 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -11290 0 0 {name=l2982 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -11270 0 0 {name=l2983 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -11250 0 0 {name=l2984 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -11230 0 0 {name=l2985 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -11210 0 0 {name=l2986 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -11190 0 0 {name=l2987 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -11170 0 0 {name=l2988 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -11150 0 0 {name=l2989 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -11130 0 0 {name=l2990 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -11110 0 0 {name=l2991 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -11090 0 0 {name=l2992 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -11030 0 0 {name=l2993 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -11070 2 0 {name=r2439}
C {devices/bus_connect_nolab.sym} 1490 -11090 2 0 {name=r2440}
C {devices/bus_connect_nolab.sym} 1490 -11110 2 0 {name=r2441}
C {devices/bus_connect_nolab.sym} 1490 -11130 2 0 {name=r2442}
C {devices/bus_connect_nolab.sym} 1490 -11150 2 0 {name=r2443}
C {devices/bus_connect_nolab.sym} 1490 -11170 2 0 {name=r2444}
C {devices/bus_connect_nolab.sym} 1490 -11190 2 0 {name=r2445}
C {devices/bus_connect_nolab.sym} 1490 -11210 2 0 {name=r2446}
C {devices/bus_connect_nolab.sym} 1490 -11230 2 0 {name=r2447}
C {devices/bus_connect_nolab.sym} 1490 -11250 2 0 {name=r2448}
C {devices/bus_connect_nolab.sym} 1490 -11270 2 0 {name=r2449}
C {devices/bus_connect_nolab.sym} 1490 -11290 2 0 {name=r2450}
C {devices/bus_connect_nolab.sym} 1490 -11310 2 0 {name=r2451}
C {devices/bus_connect_nolab.sym} 1490 -11330 2 0 {name=r2452}
C {devices/bus_connect_nolab.sym} 1490 -11350 2 0 {name=r2453}
C {devices/bus_connect_nolab.sym} 1490 -11370 2 0 {name=r2454}
C {devices/lab_wire.sym} 1550 -11070 0 0 {name=l2994 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -11380 0 0 {name=l2995 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -11360 0 0 {name=l2996 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -11340 0 0 {name=l2997 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -11320 0 0 {name=l2998 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -11300 0 0 {name=l2999 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -11280 0 0 {name=l3000 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -11260 0 0 {name=l3001 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -11240 0 0 {name=l3002 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -11220 0 0 {name=l3003 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -11200 0 0 {name=l3004 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -11180 0 0 {name=l3005 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -11160 0 0 {name=l3006 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -11140 0 0 {name=l3007 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -11120 0 0 {name=l3008 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -11100 0 0 {name=l3009 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -11040 0 0 {name=l3010 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -11080 2 0 {name=r2455}
C {devices/bus_connect_nolab.sym} 2220 -11100 2 0 {name=r2456}
C {devices/bus_connect_nolab.sym} 2220 -11120 2 0 {name=r2457}
C {devices/bus_connect_nolab.sym} 2220 -11140 2 0 {name=r2458}
C {devices/bus_connect_nolab.sym} 2220 -11160 2 0 {name=r2459}
C {devices/bus_connect_nolab.sym} 2220 -11180 2 0 {name=r2460}
C {devices/bus_connect_nolab.sym} 2220 -11200 2 0 {name=r2461}
C {devices/bus_connect_nolab.sym} 2220 -11220 2 0 {name=r2462}
C {devices/bus_connect_nolab.sym} 2220 -11240 2 0 {name=r2463}
C {devices/bus_connect_nolab.sym} 2220 -11260 2 0 {name=r2464}
C {devices/bus_connect_nolab.sym} 2220 -11280 2 0 {name=r2465}
C {devices/bus_connect_nolab.sym} 2220 -11300 2 0 {name=r2466}
C {devices/bus_connect_nolab.sym} 2220 -11320 2 0 {name=r2467}
C {devices/bus_connect_nolab.sym} 2220 -11340 2 0 {name=r2468}
C {devices/bus_connect_nolab.sym} 2220 -11360 2 0 {name=r2469}
C {devices/bus_connect_nolab.sym} 2220 -11380 2 0 {name=r2470}
C {devices/lab_wire.sym} 2280 -11080 0 0 {name=l3011 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -11370 0 0 {name=l3012 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -11350 0 0 {name=l3013 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -11330 0 0 {name=l3014 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -11310 0 0 {name=l3015 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -11290 0 0 {name=l3016 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -11270 0 0 {name=l3017 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -11250 0 0 {name=l3018 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -11230 0 0 {name=l3019 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -11210 0 0 {name=l3020 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -11190 0 0 {name=l3021 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -11170 0 0 {name=l3022 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -11150 0 0 {name=l3023 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -11130 0 0 {name=l3024 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -11110 0 0 {name=l3025 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -11090 0 0 {name=l3026 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -11030 0 0 {name=l3027 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -11070 2 0 {name=r2471}
C {devices/bus_connect_nolab.sym} 2920 -11090 2 0 {name=r2472}
C {devices/bus_connect_nolab.sym} 2920 -11110 2 0 {name=r2473}
C {devices/bus_connect_nolab.sym} 2920 -11130 2 0 {name=r2474}
C {devices/bus_connect_nolab.sym} 2920 -11150 2 0 {name=r2475}
C {devices/bus_connect_nolab.sym} 2920 -11170 2 0 {name=r2476}
C {devices/bus_connect_nolab.sym} 2920 -11190 2 0 {name=r2477}
C {devices/bus_connect_nolab.sym} 2920 -11210 2 0 {name=r2478}
C {devices/bus_connect_nolab.sym} 2920 -11230 2 0 {name=r2479}
C {devices/bus_connect_nolab.sym} 2920 -11250 2 0 {name=r2480}
C {devices/bus_connect_nolab.sym} 2920 -11270 2 0 {name=r2481}
C {devices/bus_connect_nolab.sym} 2920 -11290 2 0 {name=r2482}
C {devices/bus_connect_nolab.sym} 2920 -11310 2 0 {name=r2483}
C {devices/bus_connect_nolab.sym} 2920 -11330 2 0 {name=r2484}
C {devices/bus_connect_nolab.sym} 2920 -11350 2 0 {name=r2485}
C {devices/bus_connect_nolab.sym} 2920 -11370 2 0 {name=r2486}
C {devices/lab_wire.sym} 2980 -11070 0 0 {name=l3028 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -11370 0 0 {name=l3029 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -11350 0 0 {name=l3030 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -11330 0 0 {name=l3031 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -11310 0 0 {name=l3032 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -11290 0 0 {name=l3033 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -11270 0 0 {name=l3034 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -11250 0 0 {name=l3035 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -11230 0 0 {name=l3036 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -11210 0 0 {name=l3037 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -11190 0 0 {name=l3038 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -11170 0 0 {name=l3039 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -11150 0 0 {name=l3040 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -11130 0 0 {name=l3041 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -11110 0 0 {name=l3042 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -11090 0 0 {name=l3043 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -11030 0 0 {name=l3044 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -11070 2 0 {name=r2487}
C {devices/bus_connect_nolab.sym} 3630 -11090 2 0 {name=r2488}
C {devices/bus_connect_nolab.sym} 3630 -11110 2 0 {name=r2489}
C {devices/bus_connect_nolab.sym} 3630 -11130 2 0 {name=r2490}
C {devices/bus_connect_nolab.sym} 3630 -11150 2 0 {name=r2491}
C {devices/bus_connect_nolab.sym} 3630 -11170 2 0 {name=r2492}
C {devices/bus_connect_nolab.sym} 3630 -11190 2 0 {name=r2493}
C {devices/bus_connect_nolab.sym} 3630 -11210 2 0 {name=r2494}
C {devices/bus_connect_nolab.sym} 3630 -11230 2 0 {name=r2495}
C {devices/bus_connect_nolab.sym} 3630 -11250 2 0 {name=r2496}
C {devices/bus_connect_nolab.sym} 3630 -11270 2 0 {name=r2497}
C {devices/bus_connect_nolab.sym} 3630 -11290 2 0 {name=r2498}
C {devices/bus_connect_nolab.sym} 3630 -11310 2 0 {name=r2499}
C {devices/bus_connect_nolab.sym} 3630 -11330 2 0 {name=r2500}
C {devices/bus_connect_nolab.sym} 3630 -11350 2 0 {name=r2501}
C {devices/bus_connect_nolab.sym} 3630 -11370 2 0 {name=r2502}
C {devices/lab_wire.sym} 3690 -11070 0 0 {name=l3045 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} 40 -11420 2 0 {name=r2503}
C {devices/bus_connect_nolab.sym} 40 -11440 2 0 {name=r2504}
C {devices/bus_connect_nolab.sym} 40 -11460 2 0 {name=r2505}
C {devices/bus_connect_nolab.sym} 40 -11480 2 0 {name=r2506}
C {devices/bus_connect_nolab.sym} 40 -11500 2 0 {name=r2507}
C {devices/bus_connect_nolab.sym} 40 -11520 2 0 {name=r2508}
C {devices/bus_connect_nolab.sym} 40 -11540 2 0 {name=r2509}
C {devices/bus_connect_nolab.sym} 40 -11560 2 0 {name=r2510}
C {devices/bus_connect_nolab.sym} 40 -11580 2 0 {name=r2511}
C {devices/bus_connect_nolab.sym} 40 -11600 2 0 {name=r2512}
C {devices/bus_connect_nolab.sym} 40 -11640 2 0 {name=r2513}
C {devices/bus_connect_nolab.sym} 40 -11620 2 0 {name=r2514}
C {devices/bus_connect_nolab.sym} 40 -11680 2 0 {name=r2515}
C {devices/bus_connect_nolab.sym} 40 -11660 2 0 {name=r2516}
C {devices/bus_connect_nolab.sym} 40 -11720 2 0 {name=r2517}
C {devices/bus_connect_nolab.sym} 40 -11700 2 0 {name=r2518}
C {devices/lab_wire.sym} 90 -11420 0 0 {name=l3046 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -11440 0 0 {name=l3047 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -11460 0 0 {name=l3048 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -11460 0 0 {name=l3049 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -11480 0 0 {name=l3050 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -11500 0 0 {name=l3051 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -11520 0 0 {name=l3052 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -11540 0 0 {name=l3053 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -11560 0 0 {name=l3054 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -11580 0 0 {name=l3055 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -11600 0 0 {name=l3056 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -11640 0 0 {name=l3057 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -11620 0 0 {name=l3058 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -11660 0 0 {name=l3059 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -11680 0 0 {name=l3060 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -11700 0 0 {name=l3061 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -11720 0 0 {name=l3062 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -11370 3 0 {name=l3063 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -11420 2 1 {name=r2519}
C {devices/bus_connect_nolab.sym} 660 -11440 2 1 {name=r2520}
C {devices/bus_connect_nolab.sym} 660 -11460 2 1 {name=r2521}
C {devices/bus_connect_nolab.sym} 660 -11480 2 1 {name=r2522}
C {devices/bus_connect_nolab.sym} 660 -11500 2 1 {name=r2523}
C {devices/bus_connect_nolab.sym} 660 -11520 2 1 {name=r2524}
C {devices/bus_connect_nolab.sym} 660 -11540 2 1 {name=r2525}
C {devices/bus_connect_nolab.sym} 660 -11560 2 1 {name=r2526}
C {devices/bus_connect_nolab.sym} 660 -11580 2 1 {name=r2527}
C {devices/bus_connect_nolab.sym} 660 -11600 2 1 {name=r2528}
C {devices/bus_connect_nolab.sym} 660 -11620 2 1 {name=r2529}
C {devices/bus_connect_nolab.sym} 660 -11640 2 1 {name=r2530}
C {devices/bus_connect_nolab.sym} 660 -11660 2 1 {name=r2531}
C {devices/bus_connect_nolab.sym} 660 -11680 2 1 {name=r2532}
C {devices/bus_connect_nolab.sym} 660 -11700 2 1 {name=r2533}
C {devices/bus_connect_nolab.sym} 660 -11720 2 1 {name=r2534}
C {devices/lab_pin.sym} 670 -11370 3 0 {name=l3064 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -11720 0 1 {name=l3065 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -11700 0 1 {name=l3066 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -11680 0 1 {name=l3067 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -11660 0 1 {name=l3068 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -11640 0 1 {name=l3069 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -11620 0 1 {name=l3070 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -11600 0 1 {name=l3071 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -11580 0 1 {name=l3072 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -11560 0 1 {name=l3073 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -11540 0 1 {name=l3074 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -11520 0 1 {name=l3075 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -11500 0 1 {name=l3076 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -11480 0 1 {name=l3077 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -11460 0 1 {name=l3078 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -11440 0 1 {name=l3079 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -11420 0 1 {name=l3080 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 190 -10740 2 0 {name=r2535}
C {devices/bus_connect_nolab.sym} 190 -10760 2 0 {name=r2536}
C {devices/bus_connect_nolab.sym} 190 -10780 2 0 {name=r2537}
C {devices/bus_connect_nolab.sym} 190 -10800 2 0 {name=r2538}
C {devices/bus_connect_nolab.sym} 190 -10820 2 0 {name=r2539}
C {devices/bus_connect_nolab.sym} 190 -10840 2 0 {name=r2540}
C {devices/bus_connect_nolab.sym} 190 -10860 2 0 {name=r2541}
C {devices/bus_connect_nolab.sym} 190 -10880 2 0 {name=r2542}
C {devices/bus_connect_nolab.sym} 190 -10900 2 0 {name=r2543}
C {devices/bus_connect_nolab.sym} 190 -10920 2 0 {name=r2544}
C {devices/bus_connect_nolab.sym} 190 -10940 2 0 {name=r2545}
C {devices/bus_connect_nolab.sym} 190 -10960 2 0 {name=r2546}
C {devices/bus_connect_nolab.sym} 190 -10980 2 0 {name=r2547}
C {devices/bus_connect_nolab.sym} 190 -11000 2 0 {name=r2548}
C {devices/bus_connect_nolab.sym} 190 -11020 2 0 {name=r2549}
C {devices/bus_connect_nolab.sym} 190 -11040 2 0 {name=r2550}
C {devices/lab_pin.sym} 180 -10700 3 0 {name=l3081 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -10740 2 1 {name=r2551}
C {devices/bus_connect_nolab.sym} 610 -10760 2 1 {name=r2552}
C {devices/bus_connect_nolab.sym} 610 -10780 2 1 {name=r2553}
C {devices/bus_connect_nolab.sym} 610 -10800 2 1 {name=r2554}
C {devices/bus_connect_nolab.sym} 610 -10820 2 1 {name=r2555}
C {devices/bus_connect_nolab.sym} 610 -10840 2 1 {name=r2556}
C {devices/bus_connect_nolab.sym} 610 -10860 2 1 {name=r2557}
C {devices/bus_connect_nolab.sym} 610 -10880 2 1 {name=r2558}
C {devices/bus_connect_nolab.sym} 610 -10900 2 1 {name=r2559}
C {devices/bus_connect_nolab.sym} 610 -10920 2 1 {name=r2560}
C {devices/bus_connect_nolab.sym} 610 -10940 2 1 {name=r2561}
C {devices/bus_connect_nolab.sym} 610 -10960 2 1 {name=r2562}
C {devices/bus_connect_nolab.sym} 610 -10980 2 1 {name=r2563}
C {devices/bus_connect_nolab.sym} 610 -11000 2 1 {name=r2564}
C {devices/bus_connect_nolab.sym} 610 -11020 2 1 {name=r2565}
C {devices/bus_connect_nolab.sym} 610 -11040 2 1 {name=r2566}
C {devices/lab_pin.sym} 620 -10700 1 1 {name=l3082 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -10760 0 0 {name=l3083 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -10780 0 0 {name=l3084 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -10800 0 0 {name=l3085 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -10820 0 0 {name=l3086 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -10840 0 0 {name=l3087 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -10860 0 0 {name=l3088 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -10880 0 0 {name=l3089 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -10900 0 0 {name=l3090 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -10920 0 0 {name=l3091 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -10960 0 0 {name=l3092 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -10940 0 0 {name=l3093 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -10980 0 0 {name=l3094 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -11000 0 0 {name=l3095 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -11020 0 0 {name=l3096 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -11040 0 0 {name=l3097 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -10740 0 0 {name=l3098 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -10760 0 1 {name=l3099 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -10780 0 1 {name=l3100 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -10800 0 1 {name=l3101 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -10820 0 1 {name=l3102 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -10840 0 1 {name=l3103 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -10860 0 1 {name=l3104 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -10880 0 1 {name=l3105 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -10900 0 1 {name=l3106 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -10920 0 1 {name=l3107 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -10960 0 1 {name=l3108 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -10940 0 1 {name=l3109 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -10980 0 1 {name=l3110 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -11000 0 1 {name=l3111 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -11020 0 1 {name=l3112 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -11040 0 1 {name=l3113 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -10740 0 1 {name=l3114 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -12020 0 0 {name=l3115 lab=row5_sel}
C {devices/lab_pin.sym} 910 -12000 0 0 {name=l3116 lab=col1_sel}
C {devices/bus_connect_nolab.sym} 760 -11420 2 0 {name=r2567}
C {devices/bus_connect_nolab.sym} 760 -11440 2 0 {name=r2568}
C {devices/bus_connect_nolab.sym} 760 -11460 2 0 {name=r2569}
C {devices/bus_connect_nolab.sym} 760 -11480 2 0 {name=r2570}
C {devices/bus_connect_nolab.sym} 760 -11500 2 0 {name=r2571}
C {devices/bus_connect_nolab.sym} 760 -11520 2 0 {name=r2572}
C {devices/bus_connect_nolab.sym} 760 -11540 2 0 {name=r2573}
C {devices/bus_connect_nolab.sym} 760 -11560 2 0 {name=r2574}
C {devices/bus_connect_nolab.sym} 760 -11580 2 0 {name=r2575}
C {devices/bus_connect_nolab.sym} 760 -11600 2 0 {name=r2576}
C {devices/bus_connect_nolab.sym} 760 -11640 2 0 {name=r2577}
C {devices/bus_connect_nolab.sym} 760 -11620 2 0 {name=r2578}
C {devices/bus_connect_nolab.sym} 760 -11680 2 0 {name=r2579}
C {devices/bus_connect_nolab.sym} 760 -11660 2 0 {name=r2580}
C {devices/bus_connect_nolab.sym} 760 -11720 2 0 {name=r2581}
C {devices/bus_connect_nolab.sym} 760 -11700 2 0 {name=r2582}
C {devices/lab_wire.sym} 810 -11420 0 0 {name=l3117 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -11440 0 0 {name=l3118 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -11460 0 0 {name=l3119 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -11460 0 0 {name=l3120 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -11480 0 0 {name=l3121 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -11500 0 0 {name=l3122 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -11520 0 0 {name=l3123 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -11540 0 0 {name=l3124 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -11560 0 0 {name=l3125 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -11580 0 0 {name=l3126 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -11600 0 0 {name=l3127 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -11640 0 0 {name=l3128 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -11620 0 0 {name=l3129 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -11660 0 0 {name=l3130 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -11680 0 0 {name=l3131 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -11700 0 0 {name=l3132 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -11720 0 0 {name=l3133 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -11370 3 0 {name=l3134 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -11420 2 1 {name=r2583}
C {devices/bus_connect_nolab.sym} 1380 -11440 2 1 {name=r2584}
C {devices/bus_connect_nolab.sym} 1380 -11460 2 1 {name=r2585}
C {devices/bus_connect_nolab.sym} 1380 -11480 2 1 {name=r2586}
C {devices/bus_connect_nolab.sym} 1380 -11500 2 1 {name=r2587}
C {devices/bus_connect_nolab.sym} 1380 -11520 2 1 {name=r2588}
C {devices/bus_connect_nolab.sym} 1380 -11540 2 1 {name=r2589}
C {devices/bus_connect_nolab.sym} 1380 -11560 2 1 {name=r2590}
C {devices/bus_connect_nolab.sym} 1380 -11580 2 1 {name=r2591}
C {devices/bus_connect_nolab.sym} 1380 -11600 2 1 {name=r2592}
C {devices/bus_connect_nolab.sym} 1380 -11620 2 1 {name=r2593}
C {devices/bus_connect_nolab.sym} 1380 -11640 2 1 {name=r2594}
C {devices/bus_connect_nolab.sym} 1380 -11660 2 1 {name=r2595}
C {devices/bus_connect_nolab.sym} 1380 -11680 2 1 {name=r2596}
C {devices/bus_connect_nolab.sym} 1380 -11700 2 1 {name=r2597}
C {devices/bus_connect_nolab.sym} 1380 -11720 2 1 {name=r2598}
C {devices/lab_pin.sym} 1390 -11370 3 0 {name=l3135 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -11720 0 1 {name=l3136 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -11700 0 1 {name=l3137 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -11680 0 1 {name=l3138 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -11660 0 1 {name=l3139 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -11640 0 1 {name=l3140 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -11620 0 1 {name=l3141 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -11600 0 1 {name=l3142 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -11580 0 1 {name=l3143 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -11560 0 1 {name=l3144 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -11540 0 1 {name=l3145 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -11520 0 1 {name=l3146 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -11500 0 1 {name=l3147 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -11480 0 1 {name=l3148 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -11460 0 1 {name=l3149 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -11440 0 1 {name=l3150 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -11420 0 1 {name=l3151 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -11940 0 0 {name=l3152 lab=Vgpr}
C {devices/lab_pin.sym} 910 -11980 0 0 {name=l3153 lab=Vgnr}
C {devices/lab_pin.sym} 910 -11960 0 0 {name=l3154 lab=WR}
C {devices/lab_pin.sym} 910 -11880 2 1 {name=l3155 lab=Vrplus}
C {devices/lab_pin.sym} 910 -11820 0 0 {name=l3156 lab=Vref}
C {devices/lab_pin.sym} 910 -11780 0 0 {name=l3157 lab=Vcplus}
C {devices/lab_pin.sym} 910 -11800 0 0 {name=l3158 lab=Vcminus}
C {devices/lab_pin.sym} 910 -11840 2 1 {name=l3159 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -11860 2 1 {name=l3160 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -11980 2 0 {name=l3161 lab=vdda1}
C {devices/lab_pin.sym} 1330 -12000 2 0 {name=l3163 lab=vccd1}
C {devices/lab_pin.sym} 1610 -11890 2 1 {name=l3164 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -11910 0 0 {name=l3165 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -12010 0 0 {name=l3166 lab=row5_sel}
C {devices/lab_pin.sym} 1610 -11990 0 0 {name=l3167 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -11930 0 0 {name=l3168 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -11970 0 0 {name=l3169 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -11950 0 0 {name=l3170 lab=WR}
C {devices/lab_pin.sym} 1610 -11870 2 1 {name=l3171 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -11810 0 0 {name=l3172 lab=Vref}
C {devices/lab_pin.sym} 1610 -11770 0 0 {name=l3173 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -11790 0 0 {name=l3174 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -11830 2 1 {name=l3175 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -11850 2 1 {name=l3176 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -11970 2 0 {name=l3177 lab=vdda1}
C {devices/lab_pin.sym} 2030 -11990 2 0 {name=l3179 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -11410 2 0 {name=r2599}
C {devices/bus_connect_nolab.sym} 1460 -11430 2 0 {name=r2600}
C {devices/bus_connect_nolab.sym} 1460 -11450 2 0 {name=r2601}
C {devices/bus_connect_nolab.sym} 1460 -11470 2 0 {name=r2602}
C {devices/bus_connect_nolab.sym} 1460 -11490 2 0 {name=r2603}
C {devices/bus_connect_nolab.sym} 1460 -11510 2 0 {name=r2604}
C {devices/bus_connect_nolab.sym} 1460 -11530 2 0 {name=r2605}
C {devices/bus_connect_nolab.sym} 1460 -11550 2 0 {name=r2606}
C {devices/bus_connect_nolab.sym} 1460 -11570 2 0 {name=r2607}
C {devices/bus_connect_nolab.sym} 1460 -11590 2 0 {name=r2608}
C {devices/bus_connect_nolab.sym} 1460 -11630 2 0 {name=r2609}
C {devices/bus_connect_nolab.sym} 1460 -11610 2 0 {name=r2610}
C {devices/bus_connect_nolab.sym} 1460 -11670 2 0 {name=r2611}
C {devices/bus_connect_nolab.sym} 1460 -11650 2 0 {name=r2612}
C {devices/bus_connect_nolab.sym} 1460 -11710 2 0 {name=r2613}
C {devices/bus_connect_nolab.sym} 1460 -11690 2 0 {name=r2614}
C {devices/lab_wire.sym} 1510 -11410 0 0 {name=l3180 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -11430 0 0 {name=l3181 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -11450 0 0 {name=l3182 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -11450 0 0 {name=l3183 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -11470 0 0 {name=l3184 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -11490 0 0 {name=l3185 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -11510 0 0 {name=l3186 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -11530 0 0 {name=l3187 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -11550 0 0 {name=l3188 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -11570 0 0 {name=l3189 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -11590 0 0 {name=l3190 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -11630 0 0 {name=l3191 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -11610 0 0 {name=l3192 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -11650 0 0 {name=l3193 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -11670 0 0 {name=l3194 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -11690 0 0 {name=l3195 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -11710 0 0 {name=l3196 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -11360 3 0 {name=l3197 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -11410 2 1 {name=r2615}
C {devices/bus_connect_nolab.sym} 2080 -11430 2 1 {name=r2616}
C {devices/bus_connect_nolab.sym} 2080 -11450 2 1 {name=r2617}
C {devices/bus_connect_nolab.sym} 2080 -11470 2 1 {name=r2618}
C {devices/bus_connect_nolab.sym} 2080 -11490 2 1 {name=r2619}
C {devices/bus_connect_nolab.sym} 2080 -11510 2 1 {name=r2620}
C {devices/bus_connect_nolab.sym} 2080 -11530 2 1 {name=r2621}
C {devices/bus_connect_nolab.sym} 2080 -11550 2 1 {name=r2622}
C {devices/bus_connect_nolab.sym} 2080 -11570 2 1 {name=r2623}
C {devices/bus_connect_nolab.sym} 2080 -11590 2 1 {name=r2624}
C {devices/bus_connect_nolab.sym} 2080 -11610 2 1 {name=r2625}
C {devices/bus_connect_nolab.sym} 2080 -11630 2 1 {name=r2626}
C {devices/bus_connect_nolab.sym} 2080 -11650 2 1 {name=r2627}
C {devices/bus_connect_nolab.sym} 2080 -11670 2 1 {name=r2628}
C {devices/bus_connect_nolab.sym} 2080 -11690 2 1 {name=r2629}
C {devices/bus_connect_nolab.sym} 2080 -11710 2 1 {name=r2630}
C {devices/lab_pin.sym} 2090 -11360 3 0 {name=l3198 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -11710 0 1 {name=l3199 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -11690 0 1 {name=l3200 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -11670 0 1 {name=l3201 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -11650 0 1 {name=l3202 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -11630 0 1 {name=l3203 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -11610 0 1 {name=l3204 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -11590 0 1 {name=l3205 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -11570 0 1 {name=l3206 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -11550 0 1 {name=l3207 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -11530 0 1 {name=l3208 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -11510 0 1 {name=l3209 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -11490 0 1 {name=l3210 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -11470 0 1 {name=l3211 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -11450 0 1 {name=l3212 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -11430 0 1 {name=l3213 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -11410 0 1 {name=l3214 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -10740 2 0 {name=r2631}
C {devices/bus_connect_nolab.sym} 910 -10760 2 0 {name=r2632}
C {devices/bus_connect_nolab.sym} 910 -10780 2 0 {name=r2633}
C {devices/bus_connect_nolab.sym} 910 -10800 2 0 {name=r2634}
C {devices/bus_connect_nolab.sym} 910 -10820 2 0 {name=r2635}
C {devices/bus_connect_nolab.sym} 910 -10840 2 0 {name=r2636}
C {devices/bus_connect_nolab.sym} 910 -10860 2 0 {name=r2637}
C {devices/bus_connect_nolab.sym} 910 -10880 2 0 {name=r2638}
C {devices/bus_connect_nolab.sym} 910 -10900 2 0 {name=r2639}
C {devices/bus_connect_nolab.sym} 910 -10920 2 0 {name=r2640}
C {devices/bus_connect_nolab.sym} 910 -10940 2 0 {name=r2641}
C {devices/bus_connect_nolab.sym} 910 -10960 2 0 {name=r2642}
C {devices/bus_connect_nolab.sym} 910 -10980 2 0 {name=r2643}
C {devices/bus_connect_nolab.sym} 910 -11000 2 0 {name=r2644}
C {devices/bus_connect_nolab.sym} 910 -11020 2 0 {name=r2645}
C {devices/bus_connect_nolab.sym} 910 -11040 2 0 {name=r2646}
C {devices/lab_pin.sym} 900 -10700 3 0 {name=l3215 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -10740 2 1 {name=r2647}
C {devices/bus_connect_nolab.sym} 1330 -10760 2 1 {name=r2648}
C {devices/bus_connect_nolab.sym} 1330 -10780 2 1 {name=r2649}
C {devices/bus_connect_nolab.sym} 1330 -10800 2 1 {name=r2650}
C {devices/bus_connect_nolab.sym} 1330 -10820 2 1 {name=r2651}
C {devices/bus_connect_nolab.sym} 1330 -10840 2 1 {name=r2652}
C {devices/bus_connect_nolab.sym} 1330 -10860 2 1 {name=r2653}
C {devices/bus_connect_nolab.sym} 1330 -10880 2 1 {name=r2654}
C {devices/bus_connect_nolab.sym} 1330 -10900 2 1 {name=r2655}
C {devices/bus_connect_nolab.sym} 1330 -10920 2 1 {name=r2656}
C {devices/bus_connect_nolab.sym} 1330 -10940 2 1 {name=r2657}
C {devices/bus_connect_nolab.sym} 1330 -10960 2 1 {name=r2658}
C {devices/bus_connect_nolab.sym} 1330 -10980 2 1 {name=r2659}
C {devices/bus_connect_nolab.sym} 1330 -11000 2 1 {name=r2660}
C {devices/bus_connect_nolab.sym} 1330 -11020 2 1 {name=r2661}
C {devices/bus_connect_nolab.sym} 1330 -11040 2 1 {name=r2662}
C {devices/lab_pin.sym} 1340 -10700 1 1 {name=l3216 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -10760 0 0 {name=l3217 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -10780 0 0 {name=l3218 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -10800 0 0 {name=l3219 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -10820 0 0 {name=l3220 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -10840 0 0 {name=l3221 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -10860 0 0 {name=l3222 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -10880 0 0 {name=l3223 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -10900 0 0 {name=l3224 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -10920 0 0 {name=l3225 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -10960 0 0 {name=l3226 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -10940 0 0 {name=l3227 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -10980 0 0 {name=l3228 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -11000 0 0 {name=l3229 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -11020 0 0 {name=l3230 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -11040 0 0 {name=l3231 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -10740 0 0 {name=l3232 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -10760 0 1 {name=l3233 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -10780 0 1 {name=l3234 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -10800 0 1 {name=l3235 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -10820 0 1 {name=l3236 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -10840 0 1 {name=l3237 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -10860 0 1 {name=l3238 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -10880 0 1 {name=l3239 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -10900 0 1 {name=l3240 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -10920 0 1 {name=l3241 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -10960 0 1 {name=l3242 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -10940 0 1 {name=l3243 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -10980 0 1 {name=l3244 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -11000 0 1 {name=l3245 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -11020 0 1 {name=l3246 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -11040 0 1 {name=l3247 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -10740 0 1 {name=l3248 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -10730 2 0 {name=r2663}
C {devices/bus_connect_nolab.sym} 1610 -10750 2 0 {name=r2664}
C {devices/bus_connect_nolab.sym} 1610 -10770 2 0 {name=r2665}
C {devices/bus_connect_nolab.sym} 1610 -10790 2 0 {name=r2666}
C {devices/bus_connect_nolab.sym} 1610 -10810 2 0 {name=r2667}
C {devices/bus_connect_nolab.sym} 1610 -10830 2 0 {name=r2668}
C {devices/bus_connect_nolab.sym} 1610 -10850 2 0 {name=r2669}
C {devices/bus_connect_nolab.sym} 1610 -10870 2 0 {name=r2670}
C {devices/bus_connect_nolab.sym} 1610 -10890 2 0 {name=r2671}
C {devices/bus_connect_nolab.sym} 1610 -10910 2 0 {name=r2672}
C {devices/bus_connect_nolab.sym} 1610 -10930 2 0 {name=r2673}
C {devices/bus_connect_nolab.sym} 1610 -10950 2 0 {name=r2674}
C {devices/bus_connect_nolab.sym} 1610 -10970 2 0 {name=r2675}
C {devices/bus_connect_nolab.sym} 1610 -10990 2 0 {name=r2676}
C {devices/bus_connect_nolab.sym} 1610 -11010 2 0 {name=r2677}
C {devices/bus_connect_nolab.sym} 1610 -11030 2 0 {name=r2678}
C {devices/lab_pin.sym} 1600 -10690 3 0 {name=l3249 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -10730 2 1 {name=r2679}
C {devices/bus_connect_nolab.sym} 2030 -10750 2 1 {name=r2680}
C {devices/bus_connect_nolab.sym} 2030 -10770 2 1 {name=r2681}
C {devices/bus_connect_nolab.sym} 2030 -10790 2 1 {name=r2682}
C {devices/bus_connect_nolab.sym} 2030 -10810 2 1 {name=r2683}
C {devices/bus_connect_nolab.sym} 2030 -10830 2 1 {name=r2684}
C {devices/bus_connect_nolab.sym} 2030 -10850 2 1 {name=r2685}
C {devices/bus_connect_nolab.sym} 2030 -10870 2 1 {name=r2686}
C {devices/bus_connect_nolab.sym} 2030 -10890 2 1 {name=r2687}
C {devices/bus_connect_nolab.sym} 2030 -10910 2 1 {name=r2688}
C {devices/bus_connect_nolab.sym} 2030 -10930 2 1 {name=r2689}
C {devices/bus_connect_nolab.sym} 2030 -10950 2 1 {name=r2690}
C {devices/bus_connect_nolab.sym} 2030 -10970 2 1 {name=r2691}
C {devices/bus_connect_nolab.sym} 2030 -10990 2 1 {name=r2692}
C {devices/bus_connect_nolab.sym} 2030 -11010 2 1 {name=r2693}
C {devices/bus_connect_nolab.sym} 2030 -11030 2 1 {name=r2694}
C {devices/lab_pin.sym} 2040 -10690 1 1 {name=l3250 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -10750 0 0 {name=l3251 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -10770 0 0 {name=l3252 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -10790 0 0 {name=l3253 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -10810 0 0 {name=l3254 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -10830 0 0 {name=l3255 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -10850 0 0 {name=l3256 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -10870 0 0 {name=l3257 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -10890 0 0 {name=l3258 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -10910 0 0 {name=l3259 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -10950 0 0 {name=l3260 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -10930 0 0 {name=l3261 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -10970 0 0 {name=l3262 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -10990 0 0 {name=l3263 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -11010 0 0 {name=l3264 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -11030 0 0 {name=l3265 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -10730 0 0 {name=l3266 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -10750 0 1 {name=l3267 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -10770 0 1 {name=l3268 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -10790 0 1 {name=l3269 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -10810 0 1 {name=l3270 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -10830 0 1 {name=l3271 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -10850 0 1 {name=l3272 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -10870 0 1 {name=l3273 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -10890 0 1 {name=l3274 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -10910 0 1 {name=l3275 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -10950 0 1 {name=l3276 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -10930 0 1 {name=l3277 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -10970 0 1 {name=l3278 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -10990 0 1 {name=l3279 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -11010 0 1 {name=l3280 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -11030 0 1 {name=l3281 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -10730 0 1 {name=l3282 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -11420 2 0 {name=r2695}
C {devices/bus_connect_nolab.sym} 2190 -11440 2 0 {name=r2696}
C {devices/bus_connect_nolab.sym} 2190 -11460 2 0 {name=r2697}
C {devices/bus_connect_nolab.sym} 2190 -11480 2 0 {name=r2698}
C {devices/bus_connect_nolab.sym} 2190 -11500 2 0 {name=r2699}
C {devices/bus_connect_nolab.sym} 2190 -11520 2 0 {name=r2700}
C {devices/bus_connect_nolab.sym} 2190 -11540 2 0 {name=r2701}
C {devices/bus_connect_nolab.sym} 2190 -11560 2 0 {name=r2702}
C {devices/bus_connect_nolab.sym} 2190 -11580 2 0 {name=r2703}
C {devices/bus_connect_nolab.sym} 2190 -11600 2 0 {name=r2704}
C {devices/bus_connect_nolab.sym} 2190 -11640 2 0 {name=r2705}
C {devices/bus_connect_nolab.sym} 2190 -11620 2 0 {name=r2706}
C {devices/bus_connect_nolab.sym} 2190 -11680 2 0 {name=r2707}
C {devices/bus_connect_nolab.sym} 2190 -11660 2 0 {name=r2708}
C {devices/bus_connect_nolab.sym} 2190 -11720 2 0 {name=r2709}
C {devices/bus_connect_nolab.sym} 2190 -11700 2 0 {name=r2710}
C {devices/lab_wire.sym} 2240 -11420 0 0 {name=l3283 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -11440 0 0 {name=l3284 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -11460 0 0 {name=l3285 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -11460 0 0 {name=l3286 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -11480 0 0 {name=l3287 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -11500 0 0 {name=l3288 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -11520 0 0 {name=l3289 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -11540 0 0 {name=l3290 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -11560 0 0 {name=l3291 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -11580 0 0 {name=l3292 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -11600 0 0 {name=l3293 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -11640 0 0 {name=l3294 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -11620 0 0 {name=l3295 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -11660 0 0 {name=l3296 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -11680 0 0 {name=l3297 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -11700 0 0 {name=l3298 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -11720 0 0 {name=l3299 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -11370 3 0 {name=l3300 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -11420 2 1 {name=r2711}
C {devices/bus_connect_nolab.sym} 2810 -11440 2 1 {name=r2712}
C {devices/bus_connect_nolab.sym} 2810 -11460 2 1 {name=r2713}
C {devices/bus_connect_nolab.sym} 2810 -11480 2 1 {name=r2714}
C {devices/bus_connect_nolab.sym} 2810 -11500 2 1 {name=r2715}
C {devices/bus_connect_nolab.sym} 2810 -11520 2 1 {name=r2716}
C {devices/bus_connect_nolab.sym} 2810 -11540 2 1 {name=r2717}
C {devices/bus_connect_nolab.sym} 2810 -11560 2 1 {name=r2718}
C {devices/bus_connect_nolab.sym} 2810 -11580 2 1 {name=r2719}
C {devices/bus_connect_nolab.sym} 2810 -11600 2 1 {name=r2720}
C {devices/bus_connect_nolab.sym} 2810 -11620 2 1 {name=r2721}
C {devices/bus_connect_nolab.sym} 2810 -11640 2 1 {name=r2722}
C {devices/bus_connect_nolab.sym} 2810 -11660 2 1 {name=r2723}
C {devices/bus_connect_nolab.sym} 2810 -11680 2 1 {name=r2724}
C {devices/bus_connect_nolab.sym} 2810 -11700 2 1 {name=r2725}
C {devices/bus_connect_nolab.sym} 2810 -11720 2 1 {name=r2726}
C {devices/lab_pin.sym} 2820 -11370 3 0 {name=l3301 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -11720 0 1 {name=l3302 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -11700 0 1 {name=l3303 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -11680 0 1 {name=l3304 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -11660 0 1 {name=l3305 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -11640 0 1 {name=l3306 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -11620 0 1 {name=l3307 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -11600 0 1 {name=l3308 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -11580 0 1 {name=l3309 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -11560 0 1 {name=l3310 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -11540 0 1 {name=l3311 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -11520 0 1 {name=l3312 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -11500 0 1 {name=l3313 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -11480 0 1 {name=l3314 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -11460 0 1 {name=l3315 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -11440 0 1 {name=l3316 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -11420 0 1 {name=l3317 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -10740 2 0 {name=r2727}
C {devices/bus_connect_nolab.sym} 2340 -10760 2 0 {name=r2728}
C {devices/bus_connect_nolab.sym} 2340 -10780 2 0 {name=r2729}
C {devices/bus_connect_nolab.sym} 2340 -10800 2 0 {name=r2730}
C {devices/bus_connect_nolab.sym} 2340 -10820 2 0 {name=r2731}
C {devices/bus_connect_nolab.sym} 2340 -10840 2 0 {name=r2732}
C {devices/bus_connect_nolab.sym} 2340 -10860 2 0 {name=r2733}
C {devices/bus_connect_nolab.sym} 2340 -10880 2 0 {name=r2734}
C {devices/bus_connect_nolab.sym} 2340 -10900 2 0 {name=r2735}
C {devices/bus_connect_nolab.sym} 2340 -10920 2 0 {name=r2736}
C {devices/bus_connect_nolab.sym} 2340 -10940 2 0 {name=r2737}
C {devices/bus_connect_nolab.sym} 2340 -10960 2 0 {name=r2738}
C {devices/bus_connect_nolab.sym} 2340 -10980 2 0 {name=r2739}
C {devices/bus_connect_nolab.sym} 2340 -11000 2 0 {name=r2740}
C {devices/bus_connect_nolab.sym} 2340 -11020 2 0 {name=r2741}
C {devices/bus_connect_nolab.sym} 2340 -11040 2 0 {name=r2742}
C {devices/lab_pin.sym} 2330 -10700 3 0 {name=l3318 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -10740 2 1 {name=r2743}
C {devices/bus_connect_nolab.sym} 2760 -10760 2 1 {name=r2744}
C {devices/bus_connect_nolab.sym} 2760 -10780 2 1 {name=r2745}
C {devices/bus_connect_nolab.sym} 2760 -10800 2 1 {name=r2746}
C {devices/bus_connect_nolab.sym} 2760 -10820 2 1 {name=r2747}
C {devices/bus_connect_nolab.sym} 2760 -10840 2 1 {name=r2748}
C {devices/bus_connect_nolab.sym} 2760 -10860 2 1 {name=r2749}
C {devices/bus_connect_nolab.sym} 2760 -10880 2 1 {name=r2750}
C {devices/bus_connect_nolab.sym} 2760 -10900 2 1 {name=r2751}
C {devices/bus_connect_nolab.sym} 2760 -10920 2 1 {name=r2752}
C {devices/bus_connect_nolab.sym} 2760 -10940 2 1 {name=r2753}
C {devices/bus_connect_nolab.sym} 2760 -10960 2 1 {name=r2754}
C {devices/bus_connect_nolab.sym} 2760 -10980 2 1 {name=r2755}
C {devices/bus_connect_nolab.sym} 2760 -11000 2 1 {name=r2756}
C {devices/bus_connect_nolab.sym} 2760 -11020 2 1 {name=r2757}
C {devices/bus_connect_nolab.sym} 2760 -11040 2 1 {name=r2758}
C {devices/lab_pin.sym} 2770 -10700 1 1 {name=l3319 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -10760 0 0 {name=l3320 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -10780 0 0 {name=l3321 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -10800 0 0 {name=l3322 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -10820 0 0 {name=l3323 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -10840 0 0 {name=l3324 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -10860 0 0 {name=l3325 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -10880 0 0 {name=l3326 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -10900 0 0 {name=l3327 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -10920 0 0 {name=l3328 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -10960 0 0 {name=l3329 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -10940 0 0 {name=l3330 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -10980 0 0 {name=l3331 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -11000 0 0 {name=l3332 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -11020 0 0 {name=l3333 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -11040 0 0 {name=l3334 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -10740 0 0 {name=l3335 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -10760 0 1 {name=l3336 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -10780 0 1 {name=l3337 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -10800 0 1 {name=l3338 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -10820 0 1 {name=l3339 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -10840 0 1 {name=l3340 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -10860 0 1 {name=l3341 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -10880 0 1 {name=l3342 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -10900 0 1 {name=l3343 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -10920 0 1 {name=l3344 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -10960 0 1 {name=l3345 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -10940 0 1 {name=l3346 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -10980 0 1 {name=l3347 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -11000 0 1 {name=l3348 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -11020 0 1 {name=l3349 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -11040 0 1 {name=l3350 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -10740 0 1 {name=l3351 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -11410 2 0 {name=r2759}
C {devices/bus_connect_nolab.sym} 2890 -11430 2 0 {name=r2760}
C {devices/bus_connect_nolab.sym} 2890 -11450 2 0 {name=r2761}
C {devices/bus_connect_nolab.sym} 2890 -11470 2 0 {name=r2762}
C {devices/bus_connect_nolab.sym} 2890 -11490 2 0 {name=r2763}
C {devices/bus_connect_nolab.sym} 2890 -11510 2 0 {name=r2764}
C {devices/bus_connect_nolab.sym} 2890 -11530 2 0 {name=r2765}
C {devices/bus_connect_nolab.sym} 2890 -11550 2 0 {name=r2766}
C {devices/bus_connect_nolab.sym} 2890 -11570 2 0 {name=r2767}
C {devices/bus_connect_nolab.sym} 2890 -11590 2 0 {name=r2768}
C {devices/bus_connect_nolab.sym} 2890 -11630 2 0 {name=r2769}
C {devices/bus_connect_nolab.sym} 2890 -11610 2 0 {name=r2770}
C {devices/bus_connect_nolab.sym} 2890 -11670 2 0 {name=r2771}
C {devices/bus_connect_nolab.sym} 2890 -11650 2 0 {name=r2772}
C {devices/bus_connect_nolab.sym} 2890 -11710 2 0 {name=r2773}
C {devices/bus_connect_nolab.sym} 2890 -11690 2 0 {name=r2774}
C {devices/lab_wire.sym} 2940 -11410 0 0 {name=l3352 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -11430 0 0 {name=l3353 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -11450 0 0 {name=l3354 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -11450 0 0 {name=l3355 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -11470 0 0 {name=l3356 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -11490 0 0 {name=l3357 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -11510 0 0 {name=l3358 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -11530 0 0 {name=l3359 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -11550 0 0 {name=l3360 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -11570 0 0 {name=l3361 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -11590 0 0 {name=l3362 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -11630 0 0 {name=l3363 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -11610 0 0 {name=l3364 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -11650 0 0 {name=l3365 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -11670 0 0 {name=l3366 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -11690 0 0 {name=l3367 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -11710 0 0 {name=l3368 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -11360 3 0 {name=l3369 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -11410 2 1 {name=r2775}
C {devices/bus_connect_nolab.sym} 3510 -11430 2 1 {name=r2776}
C {devices/bus_connect_nolab.sym} 3510 -11450 2 1 {name=r2777}
C {devices/bus_connect_nolab.sym} 3510 -11470 2 1 {name=r2778}
C {devices/bus_connect_nolab.sym} 3510 -11490 2 1 {name=r2779}
C {devices/bus_connect_nolab.sym} 3510 -11510 2 1 {name=r2780}
C {devices/bus_connect_nolab.sym} 3510 -11530 2 1 {name=r2781}
C {devices/bus_connect_nolab.sym} 3510 -11550 2 1 {name=r2782}
C {devices/bus_connect_nolab.sym} 3510 -11570 2 1 {name=r2783}
C {devices/bus_connect_nolab.sym} 3510 -11590 2 1 {name=r2784}
C {devices/bus_connect_nolab.sym} 3510 -11610 2 1 {name=r2785}
C {devices/bus_connect_nolab.sym} 3510 -11630 2 1 {name=r2786}
C {devices/bus_connect_nolab.sym} 3510 -11650 2 1 {name=r2787}
C {devices/bus_connect_nolab.sym} 3510 -11670 2 1 {name=r2788}
C {devices/bus_connect_nolab.sym} 3510 -11690 2 1 {name=r2789}
C {devices/bus_connect_nolab.sym} 3510 -11710 2 1 {name=r2790}
C {devices/lab_pin.sym} 3520 -11360 3 0 {name=l3370 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -11710 0 1 {name=l3371 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -11690 0 1 {name=l3372 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -11670 0 1 {name=l3373 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -11650 0 1 {name=l3374 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -11630 0 1 {name=l3375 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -11610 0 1 {name=l3376 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -11590 0 1 {name=l3377 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -11570 0 1 {name=l3378 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -11550 0 1 {name=l3379 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -11530 0 1 {name=l3380 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -11510 0 1 {name=l3381 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -11490 0 1 {name=l3382 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -11470 0 1 {name=l3383 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -11450 0 1 {name=l3384 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -11430 0 1 {name=l3385 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -11410 0 1 {name=l3386 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -10730 2 0 {name=r2791}
C {devices/bus_connect_nolab.sym} 3040 -10750 2 0 {name=r2792}
C {devices/bus_connect_nolab.sym} 3040 -10770 2 0 {name=r2793}
C {devices/bus_connect_nolab.sym} 3040 -10790 2 0 {name=r2794}
C {devices/bus_connect_nolab.sym} 3040 -10810 2 0 {name=r2795}
C {devices/bus_connect_nolab.sym} 3040 -10830 2 0 {name=r2796}
C {devices/bus_connect_nolab.sym} 3040 -10850 2 0 {name=r2797}
C {devices/bus_connect_nolab.sym} 3040 -10870 2 0 {name=r2798}
C {devices/bus_connect_nolab.sym} 3040 -10890 2 0 {name=r2799}
C {devices/bus_connect_nolab.sym} 3040 -10910 2 0 {name=r2800}
C {devices/bus_connect_nolab.sym} 3040 -10930 2 0 {name=r2801}
C {devices/bus_connect_nolab.sym} 3040 -10950 2 0 {name=r2802}
C {devices/bus_connect_nolab.sym} 3040 -10970 2 0 {name=r2803}
C {devices/bus_connect_nolab.sym} 3040 -10990 2 0 {name=r2804}
C {devices/bus_connect_nolab.sym} 3040 -11010 2 0 {name=r2805}
C {devices/bus_connect_nolab.sym} 3040 -11030 2 0 {name=r2806}
C {devices/lab_pin.sym} 3030 -10690 3 0 {name=l3387 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -10730 2 1 {name=r2807}
C {devices/bus_connect_nolab.sym} 3460 -10750 2 1 {name=r2808}
C {devices/bus_connect_nolab.sym} 3460 -10770 2 1 {name=r2809}
C {devices/bus_connect_nolab.sym} 3460 -10790 2 1 {name=r2810}
C {devices/bus_connect_nolab.sym} 3460 -10810 2 1 {name=r2811}
C {devices/bus_connect_nolab.sym} 3460 -10830 2 1 {name=r2812}
C {devices/bus_connect_nolab.sym} 3460 -10850 2 1 {name=r2813}
C {devices/bus_connect_nolab.sym} 3460 -10870 2 1 {name=r2814}
C {devices/bus_connect_nolab.sym} 3460 -10890 2 1 {name=r2815}
C {devices/bus_connect_nolab.sym} 3460 -10910 2 1 {name=r2816}
C {devices/bus_connect_nolab.sym} 3460 -10930 2 1 {name=r2817}
C {devices/bus_connect_nolab.sym} 3460 -10950 2 1 {name=r2818}
C {devices/bus_connect_nolab.sym} 3460 -10970 2 1 {name=r2819}
C {devices/bus_connect_nolab.sym} 3460 -10990 2 1 {name=r2820}
C {devices/bus_connect_nolab.sym} 3460 -11010 2 1 {name=r2821}
C {devices/bus_connect_nolab.sym} 3460 -11030 2 1 {name=r2822}
C {devices/lab_pin.sym} 3470 -10690 1 1 {name=l3388 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -10750 0 0 {name=l3389 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -10770 0 0 {name=l3390 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -10790 0 0 {name=l3391 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -10810 0 0 {name=l3392 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -10830 0 0 {name=l3393 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -10850 0 0 {name=l3394 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -10870 0 0 {name=l3395 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -10890 0 0 {name=l3396 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -10910 0 0 {name=l3397 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -10950 0 0 {name=l3398 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -10930 0 0 {name=l3399 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -10970 0 0 {name=l3400 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -10990 0 0 {name=l3401 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -11010 0 0 {name=l3402 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -11030 0 0 {name=l3403 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -10730 0 0 {name=l3404 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -10750 0 1 {name=l3405 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -10770 0 1 {name=l3406 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -10790 0 1 {name=l3407 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -10810 0 1 {name=l3408 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -10830 0 1 {name=l3409 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -10850 0 1 {name=l3410 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -10870 0 1 {name=l3411 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -10890 0 1 {name=l3412 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -10910 0 1 {name=l3413 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -10950 0 1 {name=l3414 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -10930 0 1 {name=l3415 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -10970 0 1 {name=l3416 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -10990 0 1 {name=l3417 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -11010 0 1 {name=l3418 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -11030 0 1 {name=l3419 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -10730 0 1 {name=l3420 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -11410 2 0 {name=r2823}
C {devices/bus_connect_nolab.sym} 3600 -11430 2 0 {name=r2824}
C {devices/bus_connect_nolab.sym} 3600 -11450 2 0 {name=r2825}
C {devices/bus_connect_nolab.sym} 3600 -11470 2 0 {name=r2826}
C {devices/bus_connect_nolab.sym} 3600 -11490 2 0 {name=r2827}
C {devices/bus_connect_nolab.sym} 3600 -11510 2 0 {name=r2828}
C {devices/bus_connect_nolab.sym} 3600 -11530 2 0 {name=r2829}
C {devices/bus_connect_nolab.sym} 3600 -11550 2 0 {name=r2830}
C {devices/bus_connect_nolab.sym} 3600 -11570 2 0 {name=r2831}
C {devices/bus_connect_nolab.sym} 3600 -11590 2 0 {name=r2832}
C {devices/bus_connect_nolab.sym} 3600 -11630 2 0 {name=r2833}
C {devices/bus_connect_nolab.sym} 3600 -11610 2 0 {name=r2834}
C {devices/bus_connect_nolab.sym} 3600 -11670 2 0 {name=r2835}
C {devices/bus_connect_nolab.sym} 3600 -11650 2 0 {name=r2836}
C {devices/bus_connect_nolab.sym} 3600 -11710 2 0 {name=r2837}
C {devices/bus_connect_nolab.sym} 3600 -11690 2 0 {name=r2838}
C {devices/lab_wire.sym} 3650 -11410 0 0 {name=l3421 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -11430 0 0 {name=l3422 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -11450 0 0 {name=l3423 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -11450 0 0 {name=l3424 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -11470 0 0 {name=l3425 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -11490 0 0 {name=l3426 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -11510 0 0 {name=l3427 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -11530 0 0 {name=l3428 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -11550 0 0 {name=l3429 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -11570 0 0 {name=l3430 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -11590 0 0 {name=l3431 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -11630 0 0 {name=l3432 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -11610 0 0 {name=l3433 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -11650 0 0 {name=l3434 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -11670 0 0 {name=l3435 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -11690 0 0 {name=l3436 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -11710 0 0 {name=l3437 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -11360 3 0 {name=l3438 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -11410 2 1 {name=r2839}
C {devices/bus_connect_nolab.sym} 4220 -11430 2 1 {name=r2840}
C {devices/bus_connect_nolab.sym} 4220 -11450 2 1 {name=r2841}
C {devices/bus_connect_nolab.sym} 4220 -11470 2 1 {name=r2842}
C {devices/bus_connect_nolab.sym} 4220 -11490 2 1 {name=r2843}
C {devices/bus_connect_nolab.sym} 4220 -11510 2 1 {name=r2844}
C {devices/bus_connect_nolab.sym} 4220 -11530 2 1 {name=r2845}
C {devices/bus_connect_nolab.sym} 4220 -11550 2 1 {name=r2846}
C {devices/bus_connect_nolab.sym} 4220 -11570 2 1 {name=r2847}
C {devices/bus_connect_nolab.sym} 4220 -11590 2 1 {name=r2848}
C {devices/bus_connect_nolab.sym} 4220 -11610 2 1 {name=r2849}
C {devices/bus_connect_nolab.sym} 4220 -11630 2 1 {name=r2850}
C {devices/bus_connect_nolab.sym} 4220 -11650 2 1 {name=r2851}
C {devices/bus_connect_nolab.sym} 4220 -11670 2 1 {name=r2852}
C {devices/bus_connect_nolab.sym} 4220 -11690 2 1 {name=r2853}
C {devices/bus_connect_nolab.sym} 4220 -11710 2 1 {name=r2854}
C {devices/lab_pin.sym} 4230 -11360 3 0 {name=l3439 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -11710 0 1 {name=l3440 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -11690 0 1 {name=l3441 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -11670 0 1 {name=l3442 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -11650 0 1 {name=l3443 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -11630 0 1 {name=l3444 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -11610 0 1 {name=l3445 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -11590 0 1 {name=l3446 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -11570 0 1 {name=l3447 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -11550 0 1 {name=l3448 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -11530 0 1 {name=l3449 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -11510 0 1 {name=l3450 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -11490 0 1 {name=l3451 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -11470 0 1 {name=l3452 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -11450 0 1 {name=l3453 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -11430 0 1 {name=l3454 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -11410 0 1 {name=l3455 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -10730 2 0 {name=r2855}
C {devices/bus_connect_nolab.sym} 3750 -10750 2 0 {name=r2856}
C {devices/bus_connect_nolab.sym} 3750 -10770 2 0 {name=r2857}
C {devices/bus_connect_nolab.sym} 3750 -10790 2 0 {name=r2858}
C {devices/bus_connect_nolab.sym} 3750 -10810 2 0 {name=r2859}
C {devices/bus_connect_nolab.sym} 3750 -10830 2 0 {name=r2860}
C {devices/bus_connect_nolab.sym} 3750 -10850 2 0 {name=r2861}
C {devices/bus_connect_nolab.sym} 3750 -10870 2 0 {name=r2862}
C {devices/bus_connect_nolab.sym} 3750 -10890 2 0 {name=r2863}
C {devices/bus_connect_nolab.sym} 3750 -10910 2 0 {name=r2864}
C {devices/bus_connect_nolab.sym} 3750 -10930 2 0 {name=r2865}
C {devices/bus_connect_nolab.sym} 3750 -10950 2 0 {name=r2866}
C {devices/bus_connect_nolab.sym} 3750 -10970 2 0 {name=r2867}
C {devices/bus_connect_nolab.sym} 3750 -10990 2 0 {name=r2868}
C {devices/bus_connect_nolab.sym} 3750 -11010 2 0 {name=r2869}
C {devices/bus_connect_nolab.sym} 3750 -11030 2 0 {name=r2870}
C {devices/lab_pin.sym} 3740 -10690 3 0 {name=l3456 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -10730 2 1 {name=r2871}
C {devices/bus_connect_nolab.sym} 4170 -10750 2 1 {name=r2872}
C {devices/bus_connect_nolab.sym} 4170 -10770 2 1 {name=r2873}
C {devices/bus_connect_nolab.sym} 4170 -10790 2 1 {name=r2874}
C {devices/bus_connect_nolab.sym} 4170 -10810 2 1 {name=r2875}
C {devices/bus_connect_nolab.sym} 4170 -10830 2 1 {name=r2876}
C {devices/bus_connect_nolab.sym} 4170 -10850 2 1 {name=r2877}
C {devices/bus_connect_nolab.sym} 4170 -10870 2 1 {name=r2878}
C {devices/bus_connect_nolab.sym} 4170 -10890 2 1 {name=r2879}
C {devices/bus_connect_nolab.sym} 4170 -10910 2 1 {name=r2880}
C {devices/bus_connect_nolab.sym} 4170 -10930 2 1 {name=r2881}
C {devices/bus_connect_nolab.sym} 4170 -10950 2 1 {name=r2882}
C {devices/bus_connect_nolab.sym} 4170 -10970 2 1 {name=r2883}
C {devices/bus_connect_nolab.sym} 4170 -10990 2 1 {name=r2884}
C {devices/bus_connect_nolab.sym} 4170 -11010 2 1 {name=r2885}
C {devices/bus_connect_nolab.sym} 4170 -11030 2 1 {name=r2886}
C {devices/lab_pin.sym} 4180 -10690 1 1 {name=l3457 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -10750 0 0 {name=l3458 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -10770 0 0 {name=l3459 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -10790 0 0 {name=l3460 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -10810 0 0 {name=l3461 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -10830 0 0 {name=l3462 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -10850 0 0 {name=l3463 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -10870 0 0 {name=l3464 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3790 -10890 0 0 {name=l3465 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -10910 0 0 {name=l3466 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -10950 0 0 {name=l3467 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -10930 0 0 {name=l3468 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -10970 0 0 {name=l3469 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -10990 0 0 {name=l3470 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -11010 0 0 {name=l3471 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -11030 0 0 {name=l3472 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -10730 0 0 {name=l3473 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -10750 0 1 {name=l3474 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -10770 0 1 {name=l3475 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -10790 0 1 {name=l3476 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -10810 0 1 {name=l3477 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -10830 0 1 {name=l3478 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -10850 0 1 {name=l3479 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -10870 0 1 {name=l3480 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -10890 0 1 {name=l3481 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -10910 0 1 {name=l3482 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -10950 0 1 {name=l3483 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -10930 0 1 {name=l3484 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -10970 0 1 {name=l3485 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -10990 0 1 {name=l3486 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -11010 0 1 {name=l3487 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -11030 0 1 {name=l3488 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -10730 0 1 {name=l3489 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -11900 2 1 {name=l3490 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -11920 0 0 {name=l3491 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -12020 0 0 {name=l3492 lab=row5_sel}
C {devices/lab_pin.sym} 2340 -12000 0 0 {name=l3493 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -11940 0 0 {name=l3494 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -11980 0 0 {name=l3495 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -11960 0 0 {name=l3496 lab=WR}
C {devices/lab_pin.sym} 2340 -11880 2 1 {name=l3497 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -11820 0 0 {name=l3498 lab=Vref}
C {devices/lab_pin.sym} 2340 -11780 0 0 {name=l3499 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -11800 0 0 {name=l3500 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -11840 2 1 {name=l3501 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -11860 2 1 {name=l3502 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -11890 2 1 {name=l3503 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -11910 0 0 {name=l3504 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -12010 0 0 {name=l3505 lab=row5_sel}
C {devices/lab_pin.sym} 3040 -11990 0 0 {name=l3506 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -11930 0 0 {name=l3507 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -11970 0 0 {name=l3508 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -11950 0 0 {name=l3509 lab=WR}
C {devices/lab_pin.sym} 3040 -11870 2 1 {name=l3510 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -11810 0 0 {name=l3511 lab=Vref}
C {devices/lab_pin.sym} 3040 -11770 0 0 {name=l3512 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -11790 0 0 {name=l3513 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -11830 2 1 {name=l3514 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -11850 2 1 {name=l3515 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -11890 2 1 {name=l3516 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -11910 0 0 {name=l3517 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -12010 0 0 {name=l3518 lab=row5_sel}
C {devices/lab_pin.sym} 3750 -11990 0 0 {name=l3519 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -11930 0 0 {name=l3520 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -11970 0 0 {name=l3521 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -11950 0 0 {name=l3522 lab=WR}
C {devices/lab_pin.sym} 3750 -11870 2 1 {name=l3523 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -11810 0 0 {name=l3524 lab=Vref}
C {devices/lab_pin.sym} 3750 -11770 0 0 {name=l3525 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -11790 0 0 {name=l3526 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -11830 2 1 {name=l3527 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -11850 2 1 {name=l3528 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -11900 2 1 {name=l3529 lab=Vrminus}
C {devices/lab_pin.sym} 190 -11920 0 0 {name=l3530 lab=SAMPLE}
C {devices/lab_pin.sym} 190 -11940 0 0 {name=l3531 lab=Vgpr}
C {devices/lab_pin.sym} 190 -11980 0 0 {name=l3532 lab=Vgnr}
C {devices/lab_pin.sym} 190 -11960 0 0 {name=l3533 lab=WR}
C {devices/lab_pin.sym} 190 -11880 2 1 {name=l3534 lab=Vrplus}
C {devices/lab_pin.sym} 190 -11820 0 0 {name=l3535 lab=Vref}
C {devices/lab_pin.sym} 190 -11780 0 0 {name=l3536 lab=Vcplus}
C {devices/lab_pin.sym} 190 -11800 0 0 {name=l3537 lab=Vcminus}
C {devices/lab_pin.sym} 190 -11840 2 1 {name=l3538 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 190 -11860 2 1 {name=l3539 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 610 -11980 2 0 {name=l3540 lab=vdda1}
C {devices/lab_pin.sym} 610 -12000 2 0 {name=l3542 lab=vccd1}
C {devices/lab_pin.sym} 610 -12020 2 0 {name=l3543 lab=latch_high0}
C {devices/lab_pin.sym} 2030 -12010 2 0 {name=l3544 lab=latch_high2}
C {devices/lab_pin.sym} 2760 -12020 2 0 {name=l3545 lab=latch_high3}
C {devices/lab_pin.sym} 3460 -12010 2 0 {name=l3546 lab=latch_high4}
C {devices/lab_pin.sym} 4170 -12010 2 0 {name=l3547 lab=latch_high5}
C {devices/lab_pin.sym} 1330 -12020 2 0 {name=l3548 lab=latch_high1}
C {devices/lab_pin.sym} 190 -14090 0 0 {name=l3549 lab=row6_sel}
C {devices/lab_pin.sym} 190 -14070 0 0 {name=l3550 lab=col0_sel}
C {devices/lab_pin.sym} 910 -13970 2 1 {name=l3551 lab=Vrminus}
C {devices/lab_pin.sym} 910 -13990 0 0 {name=l3552 lab=SAMPLE}
C {devices/lab_pin.sym} 2760 -14050 2 0 {name=l3553 lab=vdda1}
C {devices/lab_pin.sym} 2760 -14070 2 0 {name=l3555 lab=vccd1}
C {devices/lab_pin.sym} 3460 -14040 2 0 {name=l3556 lab=vdda1}
C {devices/lab_pin.sym} 3460 -14060 2 0 {name=l3558 lab=vccd1}
C {devices/lab_pin.sym} 4170 -14040 2 0 {name=l3559 lab=vdda1}
C {devices/lab_pin.sym} 4170 -14060 2 0 {name=l3561 lab=vccd1}
C {devices/lab_wire.sym} 130 -13450 0 0 {name=l3562 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -13430 0 0 {name=l3563 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -13410 0 0 {name=l3564 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -13390 0 0 {name=l3565 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -13370 0 0 {name=l3566 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -13350 0 0 {name=l3567 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -13330 0 0 {name=l3568 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -13310 0 0 {name=l3569 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -13290 0 0 {name=l3570 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -13270 0 0 {name=l3571 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -13250 0 0 {name=l3572 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -13230 0 0 {name=l3573 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -13210 0 0 {name=l3574 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -13190 0 0 {name=l3575 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -13170 0 0 {name=l3576 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -13150 0 0 {name=l3577 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -13110 3 0 {name=l3578 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -13150 2 0 {name=r2887}
C {devices/bus_connect_nolab.sym} 70 -13170 2 0 {name=r2888}
C {devices/bus_connect_nolab.sym} 70 -13190 2 0 {name=r2889}
C {devices/bus_connect_nolab.sym} 70 -13210 2 0 {name=r2890}
C {devices/bus_connect_nolab.sym} 70 -13230 2 0 {name=r2891}
C {devices/bus_connect_nolab.sym} 70 -13250 2 0 {name=r2892}
C {devices/bus_connect_nolab.sym} 70 -13270 2 0 {name=r2893}
C {devices/bus_connect_nolab.sym} 70 -13290 2 0 {name=r2894}
C {devices/bus_connect_nolab.sym} 70 -13310 2 0 {name=r2895}
C {devices/bus_connect_nolab.sym} 70 -13330 2 0 {name=r2896}
C {devices/bus_connect_nolab.sym} 70 -13350 2 0 {name=r2897}
C {devices/bus_connect_nolab.sym} 70 -13370 2 0 {name=r2898}
C {devices/bus_connect_nolab.sym} 70 -13390 2 0 {name=r2899}
C {devices/bus_connect_nolab.sym} 70 -13410 2 0 {name=r2900}
C {devices/bus_connect_nolab.sym} 70 -13430 2 0 {name=r2901}
C {devices/bus_connect_nolab.sym} 70 -13450 2 0 {name=r2902}
C {devices/lab_wire.sym} 850 -13450 0 0 {name=l3579 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -13430 0 0 {name=l3580 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -13410 0 0 {name=l3581 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -13390 0 0 {name=l3582 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -13370 0 0 {name=l3583 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -13350 0 0 {name=l3584 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -13330 0 0 {name=l3585 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -13310 0 0 {name=l3586 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -13290 0 0 {name=l3587 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -13270 0 0 {name=l3588 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -13250 0 0 {name=l3589 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -13230 0 0 {name=l3590 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -13210 0 0 {name=l3591 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -13190 0 0 {name=l3592 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -13170 0 0 {name=l3593 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -13110 3 0 {name=l3594 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -13150 2 0 {name=r2903}
C {devices/bus_connect_nolab.sym} 790 -13170 2 0 {name=r2904}
C {devices/bus_connect_nolab.sym} 790 -13190 2 0 {name=r2905}
C {devices/bus_connect_nolab.sym} 790 -13210 2 0 {name=r2906}
C {devices/bus_connect_nolab.sym} 790 -13230 2 0 {name=r2907}
C {devices/bus_connect_nolab.sym} 790 -13250 2 0 {name=r2908}
C {devices/bus_connect_nolab.sym} 790 -13270 2 0 {name=r2909}
C {devices/bus_connect_nolab.sym} 790 -13290 2 0 {name=r2910}
C {devices/bus_connect_nolab.sym} 790 -13310 2 0 {name=r2911}
C {devices/bus_connect_nolab.sym} 790 -13330 2 0 {name=r2912}
C {devices/bus_connect_nolab.sym} 790 -13350 2 0 {name=r2913}
C {devices/bus_connect_nolab.sym} 790 -13370 2 0 {name=r2914}
C {devices/bus_connect_nolab.sym} 790 -13390 2 0 {name=r2915}
C {devices/bus_connect_nolab.sym} 790 -13410 2 0 {name=r2916}
C {devices/bus_connect_nolab.sym} 790 -13430 2 0 {name=r2917}
C {devices/bus_connect_nolab.sym} 790 -13450 2 0 {name=r2918}
C {devices/lab_wire.sym} 850 -13150 0 0 {name=l3595 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -13440 0 0 {name=l3596 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -13420 0 0 {name=l3597 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -13400 0 0 {name=l3598 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -13380 0 0 {name=l3599 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -13360 0 0 {name=l3600 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -13340 0 0 {name=l3601 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -13320 0 0 {name=l3602 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -13300 0 0 {name=l3603 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -13280 0 0 {name=l3604 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -13260 0 0 {name=l3605 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -13240 0 0 {name=l3606 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -13220 0 0 {name=l3607 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -13200 0 0 {name=l3608 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -13180 0 0 {name=l3609 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -13160 0 0 {name=l3610 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -13100 0 0 {name=l3611 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -13140 2 0 {name=r2919}
C {devices/bus_connect_nolab.sym} 1490 -13160 2 0 {name=r2920}
C {devices/bus_connect_nolab.sym} 1490 -13180 2 0 {name=r2921}
C {devices/bus_connect_nolab.sym} 1490 -13200 2 0 {name=r2922}
C {devices/bus_connect_nolab.sym} 1490 -13220 2 0 {name=r2923}
C {devices/bus_connect_nolab.sym} 1490 -13240 2 0 {name=r2924}
C {devices/bus_connect_nolab.sym} 1490 -13260 2 0 {name=r2925}
C {devices/bus_connect_nolab.sym} 1490 -13280 2 0 {name=r2926}
C {devices/bus_connect_nolab.sym} 1490 -13300 2 0 {name=r2927}
C {devices/bus_connect_nolab.sym} 1490 -13320 2 0 {name=r2928}
C {devices/bus_connect_nolab.sym} 1490 -13340 2 0 {name=r2929}
C {devices/bus_connect_nolab.sym} 1490 -13360 2 0 {name=r2930}
C {devices/bus_connect_nolab.sym} 1490 -13380 2 0 {name=r2931}
C {devices/bus_connect_nolab.sym} 1490 -13400 2 0 {name=r2932}
C {devices/bus_connect_nolab.sym} 1490 -13420 2 0 {name=r2933}
C {devices/bus_connect_nolab.sym} 1490 -13440 2 0 {name=r2934}
C {devices/lab_wire.sym} 1550 -13140 0 0 {name=l3612 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -13450 0 0 {name=l3613 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -13430 0 0 {name=l3614 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -13410 0 0 {name=l3615 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -13390 0 0 {name=l3616 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -13370 0 0 {name=l3617 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -13350 0 0 {name=l3618 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -13330 0 0 {name=l3619 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -13310 0 0 {name=l3620 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -13290 0 0 {name=l3621 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -13270 0 0 {name=l3622 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -13250 0 0 {name=l3623 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -13230 0 0 {name=l3624 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -13210 0 0 {name=l3625 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -13190 0 0 {name=l3626 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -13170 0 0 {name=l3627 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -13110 0 0 {name=l3628 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -13150 2 0 {name=r2935}
C {devices/bus_connect_nolab.sym} 2220 -13170 2 0 {name=r2936}
C {devices/bus_connect_nolab.sym} 2220 -13190 2 0 {name=r2937}
C {devices/bus_connect_nolab.sym} 2220 -13210 2 0 {name=r2938}
C {devices/bus_connect_nolab.sym} 2220 -13230 2 0 {name=r2939}
C {devices/bus_connect_nolab.sym} 2220 -13250 2 0 {name=r2940}
C {devices/bus_connect_nolab.sym} 2220 -13270 2 0 {name=r2941}
C {devices/bus_connect_nolab.sym} 2220 -13290 2 0 {name=r2942}
C {devices/bus_connect_nolab.sym} 2220 -13310 2 0 {name=r2943}
C {devices/bus_connect_nolab.sym} 2220 -13330 2 0 {name=r2944}
C {devices/bus_connect_nolab.sym} 2220 -13350 2 0 {name=r2945}
C {devices/bus_connect_nolab.sym} 2220 -13370 2 0 {name=r2946}
C {devices/bus_connect_nolab.sym} 2220 -13390 2 0 {name=r2947}
C {devices/bus_connect_nolab.sym} 2220 -13410 2 0 {name=r2948}
C {devices/bus_connect_nolab.sym} 2220 -13430 2 0 {name=r2949}
C {devices/bus_connect_nolab.sym} 2220 -13450 2 0 {name=r2950}
C {devices/lab_wire.sym} 2280 -13150 0 0 {name=l3629 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -13440 0 0 {name=l3630 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -13420 0 0 {name=l3631 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -13400 0 0 {name=l3632 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -13380 0 0 {name=l3633 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -13360 0 0 {name=l3634 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -13340 0 0 {name=l3635 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -13320 0 0 {name=l3636 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -13300 0 0 {name=l3637 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -13280 0 0 {name=l3638 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -13260 0 0 {name=l3639 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -13240 0 0 {name=l3640 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -13220 0 0 {name=l3641 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -13200 0 0 {name=l3642 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -13180 0 0 {name=l3643 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -13160 0 0 {name=l3644 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -13100 0 0 {name=l3645 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -13140 2 0 {name=r2951}
C {devices/bus_connect_nolab.sym} 2920 -13160 2 0 {name=r2952}
C {devices/bus_connect_nolab.sym} 2920 -13180 2 0 {name=r2953}
C {devices/bus_connect_nolab.sym} 2920 -13200 2 0 {name=r2954}
C {devices/bus_connect_nolab.sym} 2920 -13220 2 0 {name=r2955}
C {devices/bus_connect_nolab.sym} 2920 -13240 2 0 {name=r2956}
C {devices/bus_connect_nolab.sym} 2920 -13260 2 0 {name=r2957}
C {devices/bus_connect_nolab.sym} 2920 -13280 2 0 {name=r2958}
C {devices/bus_connect_nolab.sym} 2920 -13300 2 0 {name=r2959}
C {devices/bus_connect_nolab.sym} 2920 -13320 2 0 {name=r2960}
C {devices/bus_connect_nolab.sym} 2920 -13340 2 0 {name=r2961}
C {devices/bus_connect_nolab.sym} 2920 -13360 2 0 {name=r2962}
C {devices/bus_connect_nolab.sym} 2920 -13380 2 0 {name=r2963}
C {devices/bus_connect_nolab.sym} 2920 -13400 2 0 {name=r2964}
C {devices/bus_connect_nolab.sym} 2920 -13420 2 0 {name=r2965}
C {devices/bus_connect_nolab.sym} 2920 -13440 2 0 {name=r2966}
C {devices/lab_wire.sym} 2980 -13140 0 0 {name=l3646 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -13440 0 0 {name=l3647 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -13420 0 0 {name=l3648 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -13400 0 0 {name=l3649 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -13380 0 0 {name=l3650 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -13360 0 0 {name=l3651 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -13340 0 0 {name=l3652 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -13320 0 0 {name=l3653 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -13300 0 0 {name=l3654 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -13280 0 0 {name=l3655 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -13260 0 0 {name=l3656 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -13240 0 0 {name=l3657 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -13220 0 0 {name=l3658 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -13200 0 0 {name=l3659 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -13180 0 0 {name=l3660 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -13160 0 0 {name=l3661 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -13100 0 0 {name=l3662 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -13140 2 0 {name=r2967}
C {devices/bus_connect_nolab.sym} 3630 -13160 2 0 {name=r2968}
C {devices/bus_connect_nolab.sym} 3630 -13180 2 0 {name=r2969}
C {devices/bus_connect_nolab.sym} 3630 -13200 2 0 {name=r2970}
C {devices/bus_connect_nolab.sym} 3630 -13220 2 0 {name=r2971}
C {devices/bus_connect_nolab.sym} 3630 -13240 2 0 {name=r2972}
C {devices/bus_connect_nolab.sym} 3630 -13260 2 0 {name=r2973}
C {devices/bus_connect_nolab.sym} 3630 -13280 2 0 {name=r2974}
C {devices/bus_connect_nolab.sym} 3630 -13300 2 0 {name=r2975}
C {devices/bus_connect_nolab.sym} 3630 -13320 2 0 {name=r2976}
C {devices/bus_connect_nolab.sym} 3630 -13340 2 0 {name=r2977}
C {devices/bus_connect_nolab.sym} 3630 -13360 2 0 {name=r2978}
C {devices/bus_connect_nolab.sym} 3630 -13380 2 0 {name=r2979}
C {devices/bus_connect_nolab.sym} 3630 -13400 2 0 {name=r2980}
C {devices/bus_connect_nolab.sym} 3630 -13420 2 0 {name=r2981}
C {devices/bus_connect_nolab.sym} 3630 -13440 2 0 {name=r2982}
C {devices/lab_wire.sym} 3690 -13140 0 0 {name=l3663 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} 40 -13490 2 0 {name=r2983}
C {devices/bus_connect_nolab.sym} 40 -13510 2 0 {name=r2984}
C {devices/bus_connect_nolab.sym} 40 -13530 2 0 {name=r2985}
C {devices/bus_connect_nolab.sym} 40 -13550 2 0 {name=r2986}
C {devices/bus_connect_nolab.sym} 40 -13570 2 0 {name=r2987}
C {devices/bus_connect_nolab.sym} 40 -13590 2 0 {name=r2988}
C {devices/bus_connect_nolab.sym} 40 -13610 2 0 {name=r2989}
C {devices/bus_connect_nolab.sym} 40 -13630 2 0 {name=r2990}
C {devices/bus_connect_nolab.sym} 40 -13650 2 0 {name=r2991}
C {devices/bus_connect_nolab.sym} 40 -13670 2 0 {name=r2992}
C {devices/bus_connect_nolab.sym} 40 -13710 2 0 {name=r2993}
C {devices/bus_connect_nolab.sym} 40 -13690 2 0 {name=r2994}
C {devices/bus_connect_nolab.sym} 40 -13750 2 0 {name=r2995}
C {devices/bus_connect_nolab.sym} 40 -13730 2 0 {name=r2996}
C {devices/bus_connect_nolab.sym} 40 -13790 2 0 {name=r2997}
C {devices/bus_connect_nolab.sym} 40 -13770 2 0 {name=r2998}
C {devices/lab_wire.sym} 90 -13490 0 0 {name=l3664 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -13510 0 0 {name=l3665 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -13530 0 0 {name=l3666 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -13530 0 0 {name=l3667 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -13550 0 0 {name=l3668 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -13570 0 0 {name=l3669 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -13590 0 0 {name=l3670 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -13610 0 0 {name=l3671 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -13630 0 0 {name=l3672 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -13650 0 0 {name=l3673 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -13670 0 0 {name=l3674 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -13710 0 0 {name=l3675 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -13690 0 0 {name=l3676 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -13730 0 0 {name=l3677 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -13750 0 0 {name=l3678 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -13770 0 0 {name=l3679 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -13790 0 0 {name=l3680 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -13440 3 0 {name=l3681 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -13490 2 1 {name=r2999}
C {devices/bus_connect_nolab.sym} 660 -13510 2 1 {name=r3000}
C {devices/bus_connect_nolab.sym} 660 -13530 2 1 {name=r3001}
C {devices/bus_connect_nolab.sym} 660 -13550 2 1 {name=r3002}
C {devices/bus_connect_nolab.sym} 660 -13570 2 1 {name=r3003}
C {devices/bus_connect_nolab.sym} 660 -13590 2 1 {name=r3004}
C {devices/bus_connect_nolab.sym} 660 -13610 2 1 {name=r3005}
C {devices/bus_connect_nolab.sym} 660 -13630 2 1 {name=r3006}
C {devices/bus_connect_nolab.sym} 660 -13650 2 1 {name=r3007}
C {devices/bus_connect_nolab.sym} 660 -13670 2 1 {name=r3008}
C {devices/bus_connect_nolab.sym} 660 -13690 2 1 {name=r3009}
C {devices/bus_connect_nolab.sym} 660 -13710 2 1 {name=r3010}
C {devices/bus_connect_nolab.sym} 660 -13730 2 1 {name=r3011}
C {devices/bus_connect_nolab.sym} 660 -13750 2 1 {name=r3012}
C {devices/bus_connect_nolab.sym} 660 -13770 2 1 {name=r3013}
C {devices/bus_connect_nolab.sym} 660 -13790 2 1 {name=r3014}
C {devices/lab_pin.sym} 670 -13440 3 0 {name=l3682 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -13790 0 1 {name=l3683 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -13770 0 1 {name=l3684 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -13750 0 1 {name=l3685 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -13730 0 1 {name=l3686 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -13710 0 1 {name=l3687 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -13690 0 1 {name=l3688 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -13670 0 1 {name=l3689 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -13650 0 1 {name=l3690 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -13630 0 1 {name=l3691 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -13610 0 1 {name=l3692 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -13590 0 1 {name=l3693 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -13570 0 1 {name=l3694 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -13550 0 1 {name=l3695 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -13530 0 1 {name=l3696 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -13510 0 1 {name=l3697 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -13490 0 1 {name=l3698 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 190 -12810 2 0 {name=r3015}
C {devices/bus_connect_nolab.sym} 190 -12830 2 0 {name=r3016}
C {devices/bus_connect_nolab.sym} 190 -12850 2 0 {name=r3017}
C {devices/bus_connect_nolab.sym} 190 -12870 2 0 {name=r3018}
C {devices/bus_connect_nolab.sym} 190 -12890 2 0 {name=r3019}
C {devices/bus_connect_nolab.sym} 190 -12910 2 0 {name=r3020}
C {devices/bus_connect_nolab.sym} 190 -12930 2 0 {name=r3021}
C {devices/bus_connect_nolab.sym} 190 -12950 2 0 {name=r3022}
C {devices/bus_connect_nolab.sym} 190 -12970 2 0 {name=r3023}
C {devices/bus_connect_nolab.sym} 190 -12990 2 0 {name=r3024}
C {devices/bus_connect_nolab.sym} 190 -13010 2 0 {name=r3025}
C {devices/bus_connect_nolab.sym} 190 -13030 2 0 {name=r3026}
C {devices/bus_connect_nolab.sym} 190 -13050 2 0 {name=r3027}
C {devices/bus_connect_nolab.sym} 190 -13070 2 0 {name=r3028}
C {devices/bus_connect_nolab.sym} 190 -13090 2 0 {name=r3029}
C {devices/bus_connect_nolab.sym} 190 -13110 2 0 {name=r3030}
C {devices/lab_pin.sym} 180 -12770 3 0 {name=l3699 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -12810 2 1 {name=r3031}
C {devices/bus_connect_nolab.sym} 610 -12830 2 1 {name=r3032}
C {devices/bus_connect_nolab.sym} 610 -12850 2 1 {name=r3033}
C {devices/bus_connect_nolab.sym} 610 -12870 2 1 {name=r3034}
C {devices/bus_connect_nolab.sym} 610 -12890 2 1 {name=r3035}
C {devices/bus_connect_nolab.sym} 610 -12910 2 1 {name=r3036}
C {devices/bus_connect_nolab.sym} 610 -12930 2 1 {name=r3037}
C {devices/bus_connect_nolab.sym} 610 -12950 2 1 {name=r3038}
C {devices/bus_connect_nolab.sym} 610 -12970 2 1 {name=r3039}
C {devices/bus_connect_nolab.sym} 610 -12990 2 1 {name=r3040}
C {devices/bus_connect_nolab.sym} 610 -13010 2 1 {name=r3041}
C {devices/bus_connect_nolab.sym} 610 -13030 2 1 {name=r3042}
C {devices/bus_connect_nolab.sym} 610 -13050 2 1 {name=r3043}
C {devices/bus_connect_nolab.sym} 610 -13070 2 1 {name=r3044}
C {devices/bus_connect_nolab.sym} 610 -13090 2 1 {name=r3045}
C {devices/bus_connect_nolab.sym} 610 -13110 2 1 {name=r3046}
C {devices/lab_pin.sym} 620 -12770 1 1 {name=l3700 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -12830 0 0 {name=l3701 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -12850 0 0 {name=l3702 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -12870 0 0 {name=l3703 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -12890 0 0 {name=l3704 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -12910 0 0 {name=l3705 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -12930 0 0 {name=l3706 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -12950 0 0 {name=l3707 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -12970 0 0 {name=l3708 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -12990 0 0 {name=l3709 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -13030 0 0 {name=l3710 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -13010 0 0 {name=l3711 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -13050 0 0 {name=l3712 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -13070 0 0 {name=l3713 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -13090 0 0 {name=l3714 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -13110 0 0 {name=l3715 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -12810 0 0 {name=l3716 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -12830 0 1 {name=l3717 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -12850 0 1 {name=l3718 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -12870 0 1 {name=l3719 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -12890 0 1 {name=l3720 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -12910 0 1 {name=l3721 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -12930 0 1 {name=l3722 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -12950 0 1 {name=l3723 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -12970 0 1 {name=l3724 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -12990 0 1 {name=l3725 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -13030 0 1 {name=l3726 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -13010 0 1 {name=l3727 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -13050 0 1 {name=l3728 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -13070 0 1 {name=l3729 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -13090 0 1 {name=l3730 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -13110 0 1 {name=l3731 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -12810 0 1 {name=l3732 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -14090 0 0 {name=l3733 lab=row6_sel}
C {devices/lab_pin.sym} 910 -14070 0 0 {name=l3734 lab=col1_sel}
C {devices/bus_connect_nolab.sym} 760 -13490 2 0 {name=r3047}
C {devices/bus_connect_nolab.sym} 760 -13510 2 0 {name=r3048}
C {devices/bus_connect_nolab.sym} 760 -13530 2 0 {name=r3049}
C {devices/bus_connect_nolab.sym} 760 -13550 2 0 {name=r3050}
C {devices/bus_connect_nolab.sym} 760 -13570 2 0 {name=r3051}
C {devices/bus_connect_nolab.sym} 760 -13590 2 0 {name=r3052}
C {devices/bus_connect_nolab.sym} 760 -13610 2 0 {name=r3053}
C {devices/bus_connect_nolab.sym} 760 -13630 2 0 {name=r3054}
C {devices/bus_connect_nolab.sym} 760 -13650 2 0 {name=r3055}
C {devices/bus_connect_nolab.sym} 760 -13670 2 0 {name=r3056}
C {devices/bus_connect_nolab.sym} 760 -13710 2 0 {name=r3057}
C {devices/bus_connect_nolab.sym} 760 -13690 2 0 {name=r3058}
C {devices/bus_connect_nolab.sym} 760 -13750 2 0 {name=r3059}
C {devices/bus_connect_nolab.sym} 760 -13730 2 0 {name=r3060}
C {devices/bus_connect_nolab.sym} 760 -13790 2 0 {name=r3061}
C {devices/bus_connect_nolab.sym} 760 -13770 2 0 {name=r3062}
C {devices/lab_wire.sym} 810 -13490 0 0 {name=l3735 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -13510 0 0 {name=l3736 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -13530 0 0 {name=l3737 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -13530 0 0 {name=l3738 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -13550 0 0 {name=l3739 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -13570 0 0 {name=l3740 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -13590 0 0 {name=l3741 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -13610 0 0 {name=l3742 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -13630 0 0 {name=l3743 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -13650 0 0 {name=l3744 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -13670 0 0 {name=l3745 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -13710 0 0 {name=l3746 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -13690 0 0 {name=l3747 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -13730 0 0 {name=l3748 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -13750 0 0 {name=l3749 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -13770 0 0 {name=l3750 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -13790 0 0 {name=l3751 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -13440 3 0 {name=l3752 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -13490 2 1 {name=r3063}
C {devices/bus_connect_nolab.sym} 1380 -13510 2 1 {name=r3064}
C {devices/bus_connect_nolab.sym} 1380 -13530 2 1 {name=r3065}
C {devices/bus_connect_nolab.sym} 1380 -13550 2 1 {name=r3066}
C {devices/bus_connect_nolab.sym} 1380 -13570 2 1 {name=r3067}
C {devices/bus_connect_nolab.sym} 1380 -13590 2 1 {name=r3068}
C {devices/bus_connect_nolab.sym} 1380 -13610 2 1 {name=r3069}
C {devices/bus_connect_nolab.sym} 1380 -13630 2 1 {name=r3070}
C {devices/bus_connect_nolab.sym} 1380 -13650 2 1 {name=r3071}
C {devices/bus_connect_nolab.sym} 1380 -13670 2 1 {name=r3072}
C {devices/bus_connect_nolab.sym} 1380 -13690 2 1 {name=r3073}
C {devices/bus_connect_nolab.sym} 1380 -13710 2 1 {name=r3074}
C {devices/bus_connect_nolab.sym} 1380 -13730 2 1 {name=r3075}
C {devices/bus_connect_nolab.sym} 1380 -13750 2 1 {name=r3076}
C {devices/bus_connect_nolab.sym} 1380 -13770 2 1 {name=r3077}
C {devices/bus_connect_nolab.sym} 1380 -13790 2 1 {name=r3078}
C {devices/lab_pin.sym} 1390 -13440 3 0 {name=l3753 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -13790 0 1 {name=l3754 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -13770 0 1 {name=l3755 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -13750 0 1 {name=l3756 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -13730 0 1 {name=l3757 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -13710 0 1 {name=l3758 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -13690 0 1 {name=l3759 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -13670 0 1 {name=l3760 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -13650 0 1 {name=l3761 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -13630 0 1 {name=l3762 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -13610 0 1 {name=l3763 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -13590 0 1 {name=l3764 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -13570 0 1 {name=l3765 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -13550 0 1 {name=l3766 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -13530 0 1 {name=l3767 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -13510 0 1 {name=l3768 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -13490 0 1 {name=l3769 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -14010 0 0 {name=l3770 lab=Vgpr}
C {devices/lab_pin.sym} 910 -14050 0 0 {name=l3771 lab=Vgnr}
C {devices/lab_pin.sym} 910 -14030 0 0 {name=l3772 lab=WR}
C {devices/lab_pin.sym} 910 -13950 2 1 {name=l3773 lab=Vrplus}
C {devices/lab_pin.sym} 910 -13890 0 0 {name=l3774 lab=Vref}
C {devices/lab_pin.sym} 910 -13850 0 0 {name=l3775 lab=Vcplus}
C {devices/lab_pin.sym} 910 -13870 0 0 {name=l3776 lab=Vcminus}
C {devices/lab_pin.sym} 910 -13910 2 1 {name=l3777 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -13930 2 1 {name=l3778 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -14050 2 0 {name=l3779 lab=vdda1}
C {devices/lab_pin.sym} 1330 -14070 2 0 {name=l3781 lab=vccd1}
C {devices/lab_pin.sym} 1610 -13960 2 1 {name=l3782 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -13980 0 0 {name=l3783 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -14080 0 0 {name=l3784 lab=row6_sel}
C {devices/lab_pin.sym} 1610 -14060 0 0 {name=l3785 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -14000 0 0 {name=l3786 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -14040 0 0 {name=l3787 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -14020 0 0 {name=l3788 lab=WR}
C {devices/lab_pin.sym} 1610 -13940 2 1 {name=l3789 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -13880 0 0 {name=l3790 lab=Vref}
C {devices/lab_pin.sym} 1610 -13840 0 0 {name=l3791 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -13860 0 0 {name=l3792 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -13900 2 1 {name=l3793 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -13920 2 1 {name=l3794 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -14040 2 0 {name=l3795 lab=vdda1}
C {devices/lab_pin.sym} 2030 -14060 2 0 {name=l3797 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -13480 2 0 {name=r3079}
C {devices/bus_connect_nolab.sym} 1460 -13500 2 0 {name=r3080}
C {devices/bus_connect_nolab.sym} 1460 -13520 2 0 {name=r3081}
C {devices/bus_connect_nolab.sym} 1460 -13540 2 0 {name=r3082}
C {devices/bus_connect_nolab.sym} 1460 -13560 2 0 {name=r3083}
C {devices/bus_connect_nolab.sym} 1460 -13580 2 0 {name=r3084}
C {devices/bus_connect_nolab.sym} 1460 -13600 2 0 {name=r3085}
C {devices/bus_connect_nolab.sym} 1460 -13620 2 0 {name=r3086}
C {devices/bus_connect_nolab.sym} 1460 -13640 2 0 {name=r3087}
C {devices/bus_connect_nolab.sym} 1460 -13660 2 0 {name=r3088}
C {devices/bus_connect_nolab.sym} 1460 -13700 2 0 {name=r3089}
C {devices/bus_connect_nolab.sym} 1460 -13680 2 0 {name=r3090}
C {devices/bus_connect_nolab.sym} 1460 -13740 2 0 {name=r3091}
C {devices/bus_connect_nolab.sym} 1460 -13720 2 0 {name=r3092}
C {devices/bus_connect_nolab.sym} 1460 -13780 2 0 {name=r3093}
C {devices/bus_connect_nolab.sym} 1460 -13760 2 0 {name=r3094}
C {devices/lab_wire.sym} 1510 -13480 0 0 {name=l3798 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -13500 0 0 {name=l3799 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -13520 0 0 {name=l3800 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -13520 0 0 {name=l3801 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -13540 0 0 {name=l3802 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -13560 0 0 {name=l3803 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -13580 0 0 {name=l3804 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -13600 0 0 {name=l3805 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -13620 0 0 {name=l3806 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -13640 0 0 {name=l3807 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -13660 0 0 {name=l3808 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -13700 0 0 {name=l3809 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -13680 0 0 {name=l3810 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -13720 0 0 {name=l3811 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -13740 0 0 {name=l3812 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -13760 0 0 {name=l3813 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -13780 0 0 {name=l3814 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -13430 3 0 {name=l3815 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -13480 2 1 {name=r3095}
C {devices/bus_connect_nolab.sym} 2080 -13500 2 1 {name=r3096}
C {devices/bus_connect_nolab.sym} 2080 -13520 2 1 {name=r3097}
C {devices/bus_connect_nolab.sym} 2080 -13540 2 1 {name=r3098}
C {devices/bus_connect_nolab.sym} 2080 -13560 2 1 {name=r3099}
C {devices/bus_connect_nolab.sym} 2080 -13580 2 1 {name=r3100}
C {devices/bus_connect_nolab.sym} 2080 -13600 2 1 {name=r3101}
C {devices/bus_connect_nolab.sym} 2080 -13620 2 1 {name=r3102}
C {devices/bus_connect_nolab.sym} 2080 -13640 2 1 {name=r3103}
C {devices/bus_connect_nolab.sym} 2080 -13660 2 1 {name=r3104}
C {devices/bus_connect_nolab.sym} 2080 -13680 2 1 {name=r3105}
C {devices/bus_connect_nolab.sym} 2080 -13700 2 1 {name=r3106}
C {devices/bus_connect_nolab.sym} 2080 -13720 2 1 {name=r3107}
C {devices/bus_connect_nolab.sym} 2080 -13740 2 1 {name=r3108}
C {devices/bus_connect_nolab.sym} 2080 -13760 2 1 {name=r3109}
C {devices/bus_connect_nolab.sym} 2080 -13780 2 1 {name=r3110}
C {devices/lab_pin.sym} 2090 -13430 3 0 {name=l3816 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -13780 0 1 {name=l3817 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -13760 0 1 {name=l3818 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -13740 0 1 {name=l3819 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -13720 0 1 {name=l3820 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -13700 0 1 {name=l3821 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -13680 0 1 {name=l3822 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -13660 0 1 {name=l3823 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -13640 0 1 {name=l3824 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -13620 0 1 {name=l3825 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -13600 0 1 {name=l3826 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -13580 0 1 {name=l3827 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -13560 0 1 {name=l3828 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -13540 0 1 {name=l3829 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -13520 0 1 {name=l3830 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -13500 0 1 {name=l3831 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -13480 0 1 {name=l3832 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -12810 2 0 {name=r3111}
C {devices/bus_connect_nolab.sym} 910 -12830 2 0 {name=r3112}
C {devices/bus_connect_nolab.sym} 910 -12850 2 0 {name=r3113}
C {devices/bus_connect_nolab.sym} 910 -12870 2 0 {name=r3114}
C {devices/bus_connect_nolab.sym} 910 -12890 2 0 {name=r3115}
C {devices/bus_connect_nolab.sym} 910 -12910 2 0 {name=r3116}
C {devices/bus_connect_nolab.sym} 910 -12930 2 0 {name=r3117}
C {devices/bus_connect_nolab.sym} 910 -12950 2 0 {name=r3118}
C {devices/bus_connect_nolab.sym} 910 -12970 2 0 {name=r3119}
C {devices/bus_connect_nolab.sym} 910 -12990 2 0 {name=r3120}
C {devices/bus_connect_nolab.sym} 910 -13010 2 0 {name=r3121}
C {devices/bus_connect_nolab.sym} 910 -13030 2 0 {name=r3122}
C {devices/bus_connect_nolab.sym} 910 -13050 2 0 {name=r3123}
C {devices/bus_connect_nolab.sym} 910 -13070 2 0 {name=r3124}
C {devices/bus_connect_nolab.sym} 910 -13090 2 0 {name=r3125}
C {devices/bus_connect_nolab.sym} 910 -13110 2 0 {name=r3126}
C {devices/lab_pin.sym} 900 -12770 3 0 {name=l3833 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -12810 2 1 {name=r3127}
C {devices/bus_connect_nolab.sym} 1330 -12830 2 1 {name=r3128}
C {devices/bus_connect_nolab.sym} 1330 -12850 2 1 {name=r3129}
C {devices/bus_connect_nolab.sym} 1330 -12870 2 1 {name=r3130}
C {devices/bus_connect_nolab.sym} 1330 -12890 2 1 {name=r3131}
C {devices/bus_connect_nolab.sym} 1330 -12910 2 1 {name=r3132}
C {devices/bus_connect_nolab.sym} 1330 -12930 2 1 {name=r3133}
C {devices/bus_connect_nolab.sym} 1330 -12950 2 1 {name=r3134}
C {devices/bus_connect_nolab.sym} 1330 -12970 2 1 {name=r3135}
C {devices/bus_connect_nolab.sym} 1330 -12990 2 1 {name=r3136}
C {devices/bus_connect_nolab.sym} 1330 -13010 2 1 {name=r3137}
C {devices/bus_connect_nolab.sym} 1330 -13030 2 1 {name=r3138}
C {devices/bus_connect_nolab.sym} 1330 -13050 2 1 {name=r3139}
C {devices/bus_connect_nolab.sym} 1330 -13070 2 1 {name=r3140}
C {devices/bus_connect_nolab.sym} 1330 -13090 2 1 {name=r3141}
C {devices/bus_connect_nolab.sym} 1330 -13110 2 1 {name=r3142}
C {devices/lab_pin.sym} 1340 -12770 1 1 {name=l3834 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -12830 0 0 {name=l3835 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -12850 0 0 {name=l3836 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -12870 0 0 {name=l3837 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -12890 0 0 {name=l3838 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -12910 0 0 {name=l3839 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -12930 0 0 {name=l3840 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -12950 0 0 {name=l3841 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -12970 0 0 {name=l3842 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -12990 0 0 {name=l3843 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -13030 0 0 {name=l3844 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -13010 0 0 {name=l3845 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -13050 0 0 {name=l3846 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -13070 0 0 {name=l3847 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -13090 0 0 {name=l3848 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -13110 0 0 {name=l3849 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -12810 0 0 {name=l3850 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -12830 0 1 {name=l3851 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -12850 0 1 {name=l3852 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -12870 0 1 {name=l3853 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -12890 0 1 {name=l3854 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -12910 0 1 {name=l3855 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -12930 0 1 {name=l3856 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -12950 0 1 {name=l3857 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -12970 0 1 {name=l3858 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -12990 0 1 {name=l3859 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -13030 0 1 {name=l3860 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -13010 0 1 {name=l3861 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -13050 0 1 {name=l3862 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -13070 0 1 {name=l3863 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -13090 0 1 {name=l3864 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -13110 0 1 {name=l3865 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -12810 0 1 {name=l3866 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -12800 2 0 {name=r3143}
C {devices/bus_connect_nolab.sym} 1610 -12820 2 0 {name=r3144}
C {devices/bus_connect_nolab.sym} 1610 -12840 2 0 {name=r3145}
C {devices/bus_connect_nolab.sym} 1610 -12860 2 0 {name=r3146}
C {devices/bus_connect_nolab.sym} 1610 -12880 2 0 {name=r3147}
C {devices/bus_connect_nolab.sym} 1610 -12900 2 0 {name=r3148}
C {devices/bus_connect_nolab.sym} 1610 -12920 2 0 {name=r3149}
C {devices/bus_connect_nolab.sym} 1610 -12940 2 0 {name=r3150}
C {devices/bus_connect_nolab.sym} 1610 -12960 2 0 {name=r3151}
C {devices/bus_connect_nolab.sym} 1610 -12980 2 0 {name=r3152}
C {devices/bus_connect_nolab.sym} 1610 -13000 2 0 {name=r3153}
C {devices/bus_connect_nolab.sym} 1610 -13020 2 0 {name=r3154}
C {devices/bus_connect_nolab.sym} 1610 -13040 2 0 {name=r3155}
C {devices/bus_connect_nolab.sym} 1610 -13060 2 0 {name=r3156}
C {devices/bus_connect_nolab.sym} 1610 -13080 2 0 {name=r3157}
C {devices/bus_connect_nolab.sym} 1610 -13100 2 0 {name=r3158}
C {devices/lab_pin.sym} 1600 -12760 3 0 {name=l3867 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -12800 2 1 {name=r3159}
C {devices/bus_connect_nolab.sym} 2030 -12820 2 1 {name=r3160}
C {devices/bus_connect_nolab.sym} 2030 -12840 2 1 {name=r3161}
C {devices/bus_connect_nolab.sym} 2030 -12860 2 1 {name=r3162}
C {devices/bus_connect_nolab.sym} 2030 -12880 2 1 {name=r3163}
C {devices/bus_connect_nolab.sym} 2030 -12900 2 1 {name=r3164}
C {devices/bus_connect_nolab.sym} 2030 -12920 2 1 {name=r3165}
C {devices/bus_connect_nolab.sym} 2030 -12940 2 1 {name=r3166}
C {devices/bus_connect_nolab.sym} 2030 -12960 2 1 {name=r3167}
C {devices/bus_connect_nolab.sym} 2030 -12980 2 1 {name=r3168}
C {devices/bus_connect_nolab.sym} 2030 -13000 2 1 {name=r3169}
C {devices/bus_connect_nolab.sym} 2030 -13020 2 1 {name=r3170}
C {devices/bus_connect_nolab.sym} 2030 -13040 2 1 {name=r3171}
C {devices/bus_connect_nolab.sym} 2030 -13060 2 1 {name=r3172}
C {devices/bus_connect_nolab.sym} 2030 -13080 2 1 {name=r3173}
C {devices/bus_connect_nolab.sym} 2030 -13100 2 1 {name=r3174}
C {devices/lab_pin.sym} 2040 -12760 1 1 {name=l3868 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -12820 0 0 {name=l3869 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -12840 0 0 {name=l3870 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -12860 0 0 {name=l3871 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -12880 0 0 {name=l3872 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -12900 0 0 {name=l3873 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -12920 0 0 {name=l3874 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -12940 0 0 {name=l3875 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -12960 0 0 {name=l3876 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -12980 0 0 {name=l3877 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -13020 0 0 {name=l3878 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -13000 0 0 {name=l3879 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -13040 0 0 {name=l3880 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -13060 0 0 {name=l3881 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -13080 0 0 {name=l3882 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -13100 0 0 {name=l3883 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -12800 0 0 {name=l3884 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -12820 0 1 {name=l3885 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -12840 0 1 {name=l3886 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -12860 0 1 {name=l3887 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -12880 0 1 {name=l3888 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -12900 0 1 {name=l3889 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -12920 0 1 {name=l3890 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -12940 0 1 {name=l3891 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -12960 0 1 {name=l3892 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -12980 0 1 {name=l3893 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -13020 0 1 {name=l3894 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -13000 0 1 {name=l3895 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -13040 0 1 {name=l3896 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -13060 0 1 {name=l3897 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -13080 0 1 {name=l3898 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -13100 0 1 {name=l3899 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -12800 0 1 {name=l3900 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -13490 2 0 {name=r3175}
C {devices/bus_connect_nolab.sym} 2190 -13510 2 0 {name=r3176}
C {devices/bus_connect_nolab.sym} 2190 -13530 2 0 {name=r3177}
C {devices/bus_connect_nolab.sym} 2190 -13550 2 0 {name=r3178}
C {devices/bus_connect_nolab.sym} 2190 -13570 2 0 {name=r3179}
C {devices/bus_connect_nolab.sym} 2190 -13590 2 0 {name=r3180}
C {devices/bus_connect_nolab.sym} 2190 -13610 2 0 {name=r3181}
C {devices/bus_connect_nolab.sym} 2190 -13630 2 0 {name=r3182}
C {devices/bus_connect_nolab.sym} 2190 -13650 2 0 {name=r3183}
C {devices/bus_connect_nolab.sym} 2190 -13670 2 0 {name=r3184}
C {devices/bus_connect_nolab.sym} 2190 -13710 2 0 {name=r3185}
C {devices/bus_connect_nolab.sym} 2190 -13690 2 0 {name=r3186}
C {devices/bus_connect_nolab.sym} 2190 -13750 2 0 {name=r3187}
C {devices/bus_connect_nolab.sym} 2190 -13730 2 0 {name=r3188}
C {devices/bus_connect_nolab.sym} 2190 -13790 2 0 {name=r3189}
C {devices/bus_connect_nolab.sym} 2190 -13770 2 0 {name=r3190}
C {devices/lab_wire.sym} 2240 -13490 0 0 {name=l3901 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -13510 0 0 {name=l3902 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -13530 0 0 {name=l3903 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -13530 0 0 {name=l3904 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -13550 0 0 {name=l3905 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -13570 0 0 {name=l3906 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -13590 0 0 {name=l3907 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -13610 0 0 {name=l3908 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -13630 0 0 {name=l3909 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -13650 0 0 {name=l3910 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -13670 0 0 {name=l3911 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -13710 0 0 {name=l3912 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -13690 0 0 {name=l3913 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -13730 0 0 {name=l3914 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -13750 0 0 {name=l3915 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -13770 0 0 {name=l3916 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -13790 0 0 {name=l3917 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -13440 3 0 {name=l3918 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -13490 2 1 {name=r3191}
C {devices/bus_connect_nolab.sym} 2810 -13510 2 1 {name=r3192}
C {devices/bus_connect_nolab.sym} 2810 -13530 2 1 {name=r3193}
C {devices/bus_connect_nolab.sym} 2810 -13550 2 1 {name=r3194}
C {devices/bus_connect_nolab.sym} 2810 -13570 2 1 {name=r3195}
C {devices/bus_connect_nolab.sym} 2810 -13590 2 1 {name=r3196}
C {devices/bus_connect_nolab.sym} 2810 -13610 2 1 {name=r3197}
C {devices/bus_connect_nolab.sym} 2810 -13630 2 1 {name=r3198}
C {devices/bus_connect_nolab.sym} 2810 -13650 2 1 {name=r3199}
C {devices/bus_connect_nolab.sym} 2810 -13670 2 1 {name=r3200}
C {devices/bus_connect_nolab.sym} 2810 -13690 2 1 {name=r3201}
C {devices/bus_connect_nolab.sym} 2810 -13710 2 1 {name=r3202}
C {devices/bus_connect_nolab.sym} 2810 -13730 2 1 {name=r3203}
C {devices/bus_connect_nolab.sym} 2810 -13750 2 1 {name=r3204}
C {devices/bus_connect_nolab.sym} 2810 -13770 2 1 {name=r3205}
C {devices/bus_connect_nolab.sym} 2810 -13790 2 1 {name=r3206}
C {devices/lab_pin.sym} 2820 -13440 3 0 {name=l3919 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -13790 0 1 {name=l3920 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -13770 0 1 {name=l3921 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -13750 0 1 {name=l3922 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -13730 0 1 {name=l3923 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -13710 0 1 {name=l3924 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -13690 0 1 {name=l3925 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -13670 0 1 {name=l3926 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -13650 0 1 {name=l3927 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -13630 0 1 {name=l3928 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -13610 0 1 {name=l3929 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -13590 0 1 {name=l3930 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -13570 0 1 {name=l3931 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -13550 0 1 {name=l3932 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -13530 0 1 {name=l3933 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -13510 0 1 {name=l3934 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -13490 0 1 {name=l3935 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -12810 2 0 {name=r3207}
C {devices/bus_connect_nolab.sym} 2340 -12830 2 0 {name=r3208}
C {devices/bus_connect_nolab.sym} 2340 -12850 2 0 {name=r3209}
C {devices/bus_connect_nolab.sym} 2340 -12870 2 0 {name=r3210}
C {devices/bus_connect_nolab.sym} 2340 -12890 2 0 {name=r3211}
C {devices/bus_connect_nolab.sym} 2340 -12910 2 0 {name=r3212}
C {devices/bus_connect_nolab.sym} 2340 -12930 2 0 {name=r3213}
C {devices/bus_connect_nolab.sym} 2340 -12950 2 0 {name=r3214}
C {devices/bus_connect_nolab.sym} 2340 -12970 2 0 {name=r3215}
C {devices/bus_connect_nolab.sym} 2340 -12990 2 0 {name=r3216}
C {devices/bus_connect_nolab.sym} 2340 -13010 2 0 {name=r3217}
C {devices/bus_connect_nolab.sym} 2340 -13030 2 0 {name=r3218}
C {devices/bus_connect_nolab.sym} 2340 -13050 2 0 {name=r3219}
C {devices/bus_connect_nolab.sym} 2340 -13070 2 0 {name=r3220}
C {devices/bus_connect_nolab.sym} 2340 -13090 2 0 {name=r3221}
C {devices/bus_connect_nolab.sym} 2340 -13110 2 0 {name=r3222}
C {devices/lab_pin.sym} 2330 -12770 3 0 {name=l3936 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -12810 2 1 {name=r3223}
C {devices/bus_connect_nolab.sym} 2760 -12830 2 1 {name=r3224}
C {devices/bus_connect_nolab.sym} 2760 -12850 2 1 {name=r3225}
C {devices/bus_connect_nolab.sym} 2760 -12870 2 1 {name=r3226}
C {devices/bus_connect_nolab.sym} 2760 -12890 2 1 {name=r3227}
C {devices/bus_connect_nolab.sym} 2760 -12910 2 1 {name=r3228}
C {devices/bus_connect_nolab.sym} 2760 -12930 2 1 {name=r3229}
C {devices/bus_connect_nolab.sym} 2760 -12950 2 1 {name=r3230}
C {devices/bus_connect_nolab.sym} 2760 -12970 2 1 {name=r3231}
C {devices/bus_connect_nolab.sym} 2760 -12990 2 1 {name=r3232}
C {devices/bus_connect_nolab.sym} 2760 -13010 2 1 {name=r3233}
C {devices/bus_connect_nolab.sym} 2760 -13030 2 1 {name=r3234}
C {devices/bus_connect_nolab.sym} 2760 -13050 2 1 {name=r3235}
C {devices/bus_connect_nolab.sym} 2760 -13070 2 1 {name=r3236}
C {devices/bus_connect_nolab.sym} 2760 -13090 2 1 {name=r3237}
C {devices/bus_connect_nolab.sym} 2760 -13110 2 1 {name=r3238}
C {devices/lab_pin.sym} 2770 -12770 1 1 {name=l3937 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -12830 0 0 {name=l3938 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -12850 0 0 {name=l3939 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -12870 0 0 {name=l3940 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -12890 0 0 {name=l3941 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -12910 0 0 {name=l3942 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -12930 0 0 {name=l3943 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -12950 0 0 {name=l3944 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -12970 0 0 {name=l3945 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -12990 0 0 {name=l3946 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -13030 0 0 {name=l3947 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -13010 0 0 {name=l3948 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -13050 0 0 {name=l3949 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -13070 0 0 {name=l3950 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -13090 0 0 {name=l3951 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -13110 0 0 {name=l3952 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -12810 0 0 {name=l3953 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -12830 0 1 {name=l3954 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -12850 0 1 {name=l3955 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -12870 0 1 {name=l3956 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -12890 0 1 {name=l3957 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -12910 0 1 {name=l3958 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -12930 0 1 {name=l3959 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -12950 0 1 {name=l3960 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -12970 0 1 {name=l3961 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -12990 0 1 {name=l3990 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -13030 0 1 {name=l3991 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -13010 0 1 {name=l3992 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -13050 0 1 {name=l3993 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -13070 0 1 {name=l3994 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -13090 0 1 {name=l4031 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -13110 0 1 {name=l4032 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -12810 0 1 {name=l4033 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -13480 2 0 {name=r3239}
C {devices/bus_connect_nolab.sym} 2890 -13500 2 0 {name=r3240}
C {devices/bus_connect_nolab.sym} 2890 -13520 2 0 {name=r3241}
C {devices/bus_connect_nolab.sym} 2890 -13540 2 0 {name=r3242}
C {devices/bus_connect_nolab.sym} 2890 -13560 2 0 {name=r3243}
C {devices/bus_connect_nolab.sym} 2890 -13580 2 0 {name=r3244}
C {devices/bus_connect_nolab.sym} 2890 -13600 2 0 {name=r3245}
C {devices/bus_connect_nolab.sym} 2890 -13620 2 0 {name=r3246}
C {devices/bus_connect_nolab.sym} 2890 -13640 2 0 {name=r3247}
C {devices/bus_connect_nolab.sym} 2890 -13660 2 0 {name=r3248}
C {devices/bus_connect_nolab.sym} 2890 -13700 2 0 {name=r3249}
C {devices/bus_connect_nolab.sym} 2890 -13680 2 0 {name=r3250}
C {devices/bus_connect_nolab.sym} 2890 -13740 2 0 {name=r3251}
C {devices/bus_connect_nolab.sym} 2890 -13720 2 0 {name=r3252}
C {devices/bus_connect_nolab.sym} 2890 -13780 2 0 {name=r3253}
C {devices/bus_connect_nolab.sym} 2890 -13760 2 0 {name=r3254}
C {devices/lab_wire.sym} 2940 -13480 0 0 {name=l4034 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -13500 0 0 {name=l4035 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -13520 0 0 {name=l4036 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -13520 0 0 {name=l4037 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -13540 0 0 {name=l4038 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -13560 0 0 {name=l4039 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -13580 0 0 {name=l4040 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -13600 0 0 {name=l4041 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -13620 0 0 {name=l4042 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -13640 0 0 {name=l4043 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -13660 0 0 {name=l4044 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -13700 0 0 {name=l4045 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -13680 0 0 {name=l4046 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -13720 0 0 {name=l4047 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -13740 0 0 {name=l4048 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -13760 0 0 {name=l4049 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -13780 0 0 {name=l4050 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -13430 3 0 {name=l4051 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -13480 2 1 {name=r3255}
C {devices/bus_connect_nolab.sym} 3510 -13500 2 1 {name=r3256}
C {devices/bus_connect_nolab.sym} 3510 -13520 2 1 {name=r3257}
C {devices/bus_connect_nolab.sym} 3510 -13540 2 1 {name=r3258}
C {devices/bus_connect_nolab.sym} 3510 -13560 2 1 {name=r3259}
C {devices/bus_connect_nolab.sym} 3510 -13580 2 1 {name=r3260}
C {devices/bus_connect_nolab.sym} 3510 -13600 2 1 {name=r3261}
C {devices/bus_connect_nolab.sym} 3510 -13620 2 1 {name=r3262}
C {devices/bus_connect_nolab.sym} 3510 -13640 2 1 {name=r3263}
C {devices/bus_connect_nolab.sym} 3510 -13660 2 1 {name=r3264}
C {devices/bus_connect_nolab.sym} 3510 -13680 2 1 {name=r3265}
C {devices/bus_connect_nolab.sym} 3510 -13700 2 1 {name=r3266}
C {devices/bus_connect_nolab.sym} 3510 -13720 2 1 {name=r3267}
C {devices/bus_connect_nolab.sym} 3510 -13740 2 1 {name=r3268}
C {devices/bus_connect_nolab.sym} 3510 -13760 2 1 {name=r3269}
C {devices/bus_connect_nolab.sym} 3510 -13780 2 1 {name=r3270}
C {devices/lab_pin.sym} 3520 -13430 3 0 {name=l4052 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -13780 0 1 {name=l4053 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -13760 0 1 {name=l4054 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -13740 0 1 {name=l4055 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -13720 0 1 {name=l4056 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -13700 0 1 {name=l4057 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -13680 0 1 {name=l4058 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -13660 0 1 {name=l4059 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -13640 0 1 {name=l4060 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -13620 0 1 {name=l4165 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -13600 0 1 {name=l4166 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -13580 0 1 {name=l4167 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -13560 0 1 {name=l4168 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -13540 0 1 {name=l4169 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -13520 0 1 {name=l4170 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -13500 0 1 {name=l4171 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -13480 0 1 {name=l4172 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -12800 2 0 {name=r3271}
C {devices/bus_connect_nolab.sym} 3040 -12820 2 0 {name=r3272}
C {devices/bus_connect_nolab.sym} 3040 -12840 2 0 {name=r3273}
C {devices/bus_connect_nolab.sym} 3040 -12860 2 0 {name=r3274}
C {devices/bus_connect_nolab.sym} 3040 -12880 2 0 {name=r3275}
C {devices/bus_connect_nolab.sym} 3040 -12900 2 0 {name=r3276}
C {devices/bus_connect_nolab.sym} 3040 -12920 2 0 {name=r3277}
C {devices/bus_connect_nolab.sym} 3040 -12940 2 0 {name=r3278}
C {devices/bus_connect_nolab.sym} 3040 -12960 2 0 {name=r3279}
C {devices/bus_connect_nolab.sym} 3040 -12980 2 0 {name=r3280}
C {devices/bus_connect_nolab.sym} 3040 -13000 2 0 {name=r3281}
C {devices/bus_connect_nolab.sym} 3040 -13020 2 0 {name=r3282}
C {devices/bus_connect_nolab.sym} 3040 -13040 2 0 {name=r3283}
C {devices/bus_connect_nolab.sym} 3040 -13060 2 0 {name=r3284}
C {devices/bus_connect_nolab.sym} 3040 -13080 2 0 {name=r3285}
C {devices/bus_connect_nolab.sym} 3040 -13100 2 0 {name=r3286}
C {devices/lab_pin.sym} 3030 -12760 3 0 {name=l4173 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -12800 2 1 {name=r3287}
C {devices/bus_connect_nolab.sym} 3460 -12820 2 1 {name=r3288}
C {devices/bus_connect_nolab.sym} 3460 -12840 2 1 {name=r3289}
C {devices/bus_connect_nolab.sym} 3460 -12860 2 1 {name=r3290}
C {devices/bus_connect_nolab.sym} 3460 -12880 2 1 {name=r3291}
C {devices/bus_connect_nolab.sym} 3460 -12900 2 1 {name=r3292}
C {devices/bus_connect_nolab.sym} 3460 -12920 2 1 {name=r3293}
C {devices/bus_connect_nolab.sym} 3460 -12940 2 1 {name=r3294}
C {devices/bus_connect_nolab.sym} 3460 -12960 2 1 {name=r3295}
C {devices/bus_connect_nolab.sym} 3460 -12980 2 1 {name=r3296}
C {devices/bus_connect_nolab.sym} 3460 -13000 2 1 {name=r3297}
C {devices/bus_connect_nolab.sym} 3460 -13020 2 1 {name=r3298}
C {devices/bus_connect_nolab.sym} 3460 -13040 2 1 {name=r3299}
C {devices/bus_connect_nolab.sym} 3460 -13060 2 1 {name=r3300}
C {devices/bus_connect_nolab.sym} 3460 -13080 2 1 {name=r3301}
C {devices/bus_connect_nolab.sym} 3460 -13100 2 1 {name=r3302}
C {devices/lab_pin.sym} 3470 -12760 1 1 {name=l4174 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -12820 0 0 {name=l4175 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -12840 0 0 {name=l4176 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -12860 0 0 {name=l4177 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -12880 0 0 {name=l4178 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -12900 0 0 {name=l4179 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -12920 0 0 {name=l4180 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -12940 0 0 {name=l4181 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -12960 0 0 {name=l4182 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -12980 0 0 {name=l4183 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -13020 0 0 {name=l4184 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -13000 0 0 {name=l4185 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -13040 0 0 {name=l4186 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -13060 0 0 {name=l4187 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -13080 0 0 {name=l4188 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -13100 0 0 {name=l4189 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -12800 0 0 {name=l4190 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -12820 0 1 {name=l4191 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -12840 0 1 {name=l4192 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -12860 0 1 {name=l4193 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -12880 0 1 {name=l4194 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -12900 0 1 {name=l4195 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -12920 0 1 {name=l4196 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -12940 0 1 {name=l4197 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -12960 0 1 {name=l4198 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -12980 0 1 {name=l4199 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -13020 0 1 {name=l4200 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -13000 0 1 {name=l4201 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -13040 0 1 {name=l4202 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -13060 0 1 {name=l4203 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -13080 0 1 {name=l4204 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -13100 0 1 {name=l4205 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -12800 0 1 {name=l4206 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -13480 2 0 {name=r3303}
C {devices/bus_connect_nolab.sym} 3600 -13500 2 0 {name=r3304}
C {devices/bus_connect_nolab.sym} 3600 -13520 2 0 {name=r3305}
C {devices/bus_connect_nolab.sym} 3600 -13540 2 0 {name=r3306}
C {devices/bus_connect_nolab.sym} 3600 -13560 2 0 {name=r3307}
C {devices/bus_connect_nolab.sym} 3600 -13580 2 0 {name=r3308}
C {devices/bus_connect_nolab.sym} 3600 -13600 2 0 {name=r3309}
C {devices/bus_connect_nolab.sym} 3600 -13620 2 0 {name=r3310}
C {devices/bus_connect_nolab.sym} 3600 -13640 2 0 {name=r3311}
C {devices/bus_connect_nolab.sym} 3600 -13660 2 0 {name=r3312}
C {devices/bus_connect_nolab.sym} 3600 -13700 2 0 {name=r3313}
C {devices/bus_connect_nolab.sym} 3600 -13680 2 0 {name=r3314}
C {devices/bus_connect_nolab.sym} 3600 -13740 2 0 {name=r3315}
C {devices/bus_connect_nolab.sym} 3600 -13720 2 0 {name=r3316}
C {devices/bus_connect_nolab.sym} 3600 -13780 2 0 {name=r3317}
C {devices/bus_connect_nolab.sym} 3600 -13760 2 0 {name=r3318}
C {devices/lab_wire.sym} 3650 -13480 0 0 {name=l4207 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -13500 0 0 {name=l4208 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -13520 0 0 {name=l4209 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -13520 0 0 {name=l4210 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -13540 0 0 {name=l4211 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -13560 0 0 {name=l4212 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -13580 0 0 {name=l4213 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -13600 0 0 {name=l4214 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -13620 0 0 {name=l4215 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -13640 0 0 {name=l4216 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -13660 0 0 {name=l4217 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -13700 0 0 {name=l4218 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -13680 0 0 {name=l4219 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -13720 0 0 {name=l4220 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -13740 0 0 {name=l4221 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -13760 0 0 {name=l4222 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -13780 0 0 {name=l4223 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -13430 3 0 {name=l4224 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -13480 2 1 {name=r3319}
C {devices/bus_connect_nolab.sym} 4220 -13500 2 1 {name=r3320}
C {devices/bus_connect_nolab.sym} 4220 -13520 2 1 {name=r3321}
C {devices/bus_connect_nolab.sym} 4220 -13540 2 1 {name=r3322}
C {devices/bus_connect_nolab.sym} 4220 -13560 2 1 {name=r3323}
C {devices/bus_connect_nolab.sym} 4220 -13580 2 1 {name=r3324}
C {devices/bus_connect_nolab.sym} 4220 -13600 2 1 {name=r3325}
C {devices/bus_connect_nolab.sym} 4220 -13620 2 1 {name=r3326}
C {devices/bus_connect_nolab.sym} 4220 -13640 2 1 {name=r3327}
C {devices/bus_connect_nolab.sym} 4220 -13660 2 1 {name=r3328}
C {devices/bus_connect_nolab.sym} 4220 -13680 2 1 {name=r3329}
C {devices/bus_connect_nolab.sym} 4220 -13700 2 1 {name=r3330}
C {devices/bus_connect_nolab.sym} 4220 -13720 2 1 {name=r3331}
C {devices/bus_connect_nolab.sym} 4220 -13740 2 1 {name=r3332}
C {devices/bus_connect_nolab.sym} 4220 -13760 2 1 {name=r3333}
C {devices/bus_connect_nolab.sym} 4220 -13780 2 1 {name=r3334}
C {devices/lab_pin.sym} 4230 -13430 3 0 {name=l4225 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -13780 0 1 {name=l4226 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -13760 0 1 {name=l4227 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -13740 0 1 {name=l4228 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -13720 0 1 {name=l4229 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -13700 0 1 {name=l4230 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -13680 0 1 {name=l4231 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -13660 0 1 {name=l4232 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -13640 0 1 {name=l4233 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -13620 0 1 {name=l4234 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -13600 0 1 {name=l4235 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -13580 0 1 {name=l4236 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -13560 0 1 {name=l4237 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -13540 0 1 {name=l4238 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -13520 0 1 {name=l4239 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -13500 0 1 {name=l4240 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -13480 0 1 {name=l4241 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -12800 2 0 {name=r3335}
C {devices/bus_connect_nolab.sym} 3750 -12820 2 0 {name=r3336}
C {devices/bus_connect_nolab.sym} 3750 -12840 2 0 {name=r3337}
C {devices/bus_connect_nolab.sym} 3750 -12860 2 0 {name=r3338}
C {devices/bus_connect_nolab.sym} 3750 -12880 2 0 {name=r3339}
C {devices/bus_connect_nolab.sym} 3750 -12900 2 0 {name=r3340}
C {devices/bus_connect_nolab.sym} 3750 -12920 2 0 {name=r3341}
C {devices/bus_connect_nolab.sym} 3750 -12940 2 0 {name=r3342}
C {devices/bus_connect_nolab.sym} 3750 -12960 2 0 {name=r3343}
C {devices/bus_connect_nolab.sym} 3750 -12980 2 0 {name=r3344}
C {devices/bus_connect_nolab.sym} 3750 -13000 2 0 {name=r3345}
C {devices/bus_connect_nolab.sym} 3750 -13020 2 0 {name=r3346}
C {devices/bus_connect_nolab.sym} 3750 -13040 2 0 {name=r3347}
C {devices/bus_connect_nolab.sym} 3750 -13060 2 0 {name=r3348}
C {devices/bus_connect_nolab.sym} 3750 -13080 2 0 {name=r3349}
C {devices/bus_connect_nolab.sym} 3750 -13100 2 0 {name=r3350}
C {devices/lab_pin.sym} 3740 -12760 3 0 {name=l4242 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -12800 2 1 {name=r3351}
C {devices/bus_connect_nolab.sym} 4170 -12820 2 1 {name=r3352}
C {devices/bus_connect_nolab.sym} 4170 -12840 2 1 {name=r3353}
C {devices/bus_connect_nolab.sym} 4170 -12860 2 1 {name=r3354}
C {devices/bus_connect_nolab.sym} 4170 -12880 2 1 {name=r3355}
C {devices/bus_connect_nolab.sym} 4170 -12900 2 1 {name=r3356}
C {devices/bus_connect_nolab.sym} 4170 -12920 2 1 {name=r3357}
C {devices/bus_connect_nolab.sym} 4170 -12940 2 1 {name=r3358}
C {devices/bus_connect_nolab.sym} 4170 -12960 2 1 {name=r3359}
C {devices/bus_connect_nolab.sym} 4170 -12980 2 1 {name=r3360}
C {devices/bus_connect_nolab.sym} 4170 -13000 2 1 {name=r3361}
C {devices/bus_connect_nolab.sym} 4170 -13020 2 1 {name=r3362}
C {devices/bus_connect_nolab.sym} 4170 -13040 2 1 {name=r3363}
C {devices/bus_connect_nolab.sym} 4170 -13060 2 1 {name=r3364}
C {devices/bus_connect_nolab.sym} 4170 -13080 2 1 {name=r3365}
C {devices/bus_connect_nolab.sym} 4170 -13100 2 1 {name=r3366}
C {devices/lab_pin.sym} 4180 -12760 1 1 {name=l4243 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -12820 0 0 {name=l4244 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -12840 0 0 {name=l4245 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -12860 0 0 {name=l4246 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -12880 0 0 {name=l4247 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -12900 0 0 {name=l4248 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -12920 0 0 {name=l4249 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -12940 0 0 {name=l4250 sig_type=std_logic lab=cA7}
