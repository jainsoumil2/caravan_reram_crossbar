v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 190 -1210 250 -1210 {
lab=rA0}
N 600 -1210 660 -1210 {
lab=rB0}
N 600 -1230 660 -1230 {
lab=rB1}
N 600 -1250 660 -1250 {
lab=rB2}
N 600 -1270 660 -1270 {
lab=rB3}
N 600 -1290 660 -1290 {
lab=rB4}
N 600 -1310 660 -1310 {
lab=rB5}
N 600 -1330 660 -1330 {
lab=rB6}
N 600 -1350 660 -1350 {
lab=rB7}
N 600 -1370 660 -1370 {
lab=rB8}
N 600 -1390 660 -1390 {
lab=rB9}
N 600 -1410 660 -1410 {
lab=rB10}
N 600 -1430 660 -1430 {
lab=rB11}
N 600 -1450 660 -1450 {
lab=rB12}
N 600 -1470 660 -1470 {
lab=rB13}
N 600 -1490 660 -1490 {
lab=rB14}
N 600 -1510 660 -1510 {
lab=rB15}
N 190 -870 250 -870 {
lab=WL0}
N 190 -890 250 -890 {
lab=WL1}
N 190 -910 250 -910 {
lab=WL2}
N 190 -930 250 -930 {
lab=WL3}
N 190 -950 250 -950 {
lab=WL4}
N 190 -970 250 -970 {
lab=WL5}
N 190 -990 250 -990 {
lab=WL6}
N 190 -1010 250 -1010 {
lab=WL7}
N 190 -1030 250 -1030 {
lab=WL8}
N 190 -1050 250 -1050 {
lab=WL9}
N 190 -1070 250 -1070 {
lab=WL10}
N 190 -1090 250 -1090 {
lab=WL11}
N 190 -1110 250 -1110 {
lab=WL12}
N 190 -1130 250 -1130 {
lab=WL13}
N 190 -1150 250 -1150 {
lab=WL14}
N 190 -1170 250 -1170 {
lab=WL15}
N 190 -530 250 -530 {
lab=cA0}
N 190 -550 250 -550 {
lab=cA1}
N 190 -570 250 -570 {
lab=cA2}
N 190 -590 250 -590 {
lab=cA3}
N 190 -610 250 -610 {
lab=cA4}
N 190 -630 250 -630 {
lab=cA5}
N 190 -650 250 -650 {
lab=cA6}
N 190 -670 250 -670 {
lab=cA7}
N 190 -690 250 -690 {
lab=cA8}
N 190 -710 250 -710 {
lab=cA9}
N 190 -730 250 -730 {
lab=cA10}
N 190 -750 250 -750 {
lab=cA11}
N 190 -770 250 -770 {
lab=cA12}
N 190 -790 250 -790 {
lab=cA13}
N 190 -810 250 -810 {
lab=cA14}
N 190 -830 250 -830 {
lab=cA15}
N 190 -1790 250 -1790 {
lab=col0_sel}
N 190 -1810 250 -1810 {
lab=row0_sel}
N 190 -1750 250 -1750 {
lab=WR}
N 190 -1770 250 -1770 {
lab=Vgnr}
N 190 -1730 250 -1730 {
lab=Vgpr}
N 190 -1570 250 -1570 {
lab=Vcplus}
N 190 -1590 250 -1590 {
lab=Vcminus}
N 190 -1610 250 -1610 {
lab=Vref}
N 190 -1630 250 -1630 {
lab=Vref_comp}
N 190 -1650 250 -1650 {
lab=RISC_CLK}
N 550 -1750 610 -1750 {
lab=vssa1}
N 550 -1770 610 -1770 {
lab=vdda1}
N 550 -1790 610 -1790 {
lab=vccd1}
N 550 -1810 610 -1810 {
lab=latch_high0}
N 1970 -1800 2030 -1800 {
lab=latch_high2}
N 2700 -1750 2760 -1750 {
lab=vssd1}
N 2700 -1770 2760 -1770 {
lab=vdda1}
N 2700 -1790 2760 -1790 {
lab=vccd1}
N 2700 -1810 2760 -1810 {
lab=latch_high3}
N 3400 -1740 3460 -1740 {
lab=vssd1}
N 3400 -1760 3460 -1760 {
lab=vdda1}
N 3400 -1780 3460 -1780 {
lab=vccd1}
N 3400 -1800 3460 -1800 {
lab=latch_high4}
N 4110 -1740 4170 -1740 {
lab=vssd1}
N 4110 -1760 4170 -1760 {
lab=vdda1}
N 4110 -1780 4170 -1780 {
lab=vccd1}
N 4110 -1800 4170 -1800 {
lab=latch_high5}
N -400 -1700 -340 -1700 {
lab=col0_sel}
N -400 -1680 -340 -1680 {
lab=col1_sel}
N -400 -1660 -340 -1660 {
lab=col2_sel}
N -400 -1640 -340 -1640 {
lab=col3_sel}
N -400 -1620 -340 -1620 {
lab=col4_sel}
N -400 -1600 -340 -1600 {
lab=col5_sel}
N -400 -1580 -340 -1580 {
lab=#net1}
N -400 -1560 -340 -1560 {
lab=#net2}
N -760 -1700 -700 -1700 {
lab=vccd1}
N -760 -1680 -700 -1680 {
lab=vssd1}
N -760 -1660 -700 -1660 {
lab=CSEL0}
N -760 -1640 -700 -1640 {
lab=CSEL1}
N -760 -1620 -700 -1620 {
lab=CSEL2}
N -760 -1600 -700 -1600 {
lab=EN}
N -400 -1420 -340 -1420 {
lab=row0_sel}
N -400 -1400 -340 -1400 {
lab=row1_sel}
N -400 -1380 -340 -1380 {
lab=row2_sel}
N -400 -1360 -340 -1360 {
lab=row3_sel}
N -400 -1340 -340 -1340 {
lab=row4_sel}
N -400 -1320 -340 -1320 {
lab=row5_sel}
N -400 -1300 -340 -1300 {
lab=row6_sel}
N -400 -1280 -340 -1280 {
lab=#net3}
N -760 -1420 -700 -1420 {
lab=vccd1}
N -760 -1400 -700 -1400 {
lab=vssd1}
N -760 -1380 -700 -1380 {
lab=RSEL0}
N -760 -1360 -700 -1360 {
lab=RSEL1}
N -760 -1340 -700 -1340 {
lab=RSEL2}
N -760 -1320 -700 -1320 {
lab=EN}
N 130 -870 190 -870 {
lab=WL0}
N 130 -890 190 -890 {
lab=WL1}
N 130 -910 190 -910 {
lab=WL2}
N 130 -930 190 -930 {
lab=WL3}
N 130 -950 190 -950 {
lab=WL4}
N 130 -970 190 -970 {
lab=WL5}
N 130 -990 190 -990 {
lab=WL6}
N 130 -1010 190 -1010 {
lab=WL7}
N 130 -1030 190 -1030 {
lab=WL8}
N 130 -1050 190 -1050 {
lab=WL9}
N 130 -1070 190 -1070 {
lab=WL10}
N 130 -1090 190 -1090 {
lab=WL11}
N 130 -1110 190 -1110 {
lab=WL12}
N 130 -1130 190 -1130 {
lab=WL13}
N 130 -1150 190 -1150 {
lab=WL14}
N 130 -1170 190 -1170 {
lab=WL15}
N 70 -870 130 -870 {
lab=WL0}
N 70 -890 130 -890 {
lab=WL1}
N 70 -910 130 -910 {
lab=WL2}
N 70 -930 130 -930 {
lab=WL3}
N 70 -950 130 -950 {
lab=WL4}
N 70 -970 130 -970 {
lab=WL5}
N 70 -990 130 -990 {
lab=WL6}
N 70 -1010 130 -1010 {
lab=WL7}
N 70 -1030 130 -1030 {
lab=WL8}
N 70 -1050 130 -1050 {
lab=WL9}
N 70 -1070 130 -1070 {
lab=WL10}
N 70 -1090 130 -1090 {
lab=WL11}
N 70 -1110 130 -1110 {
lab=WL12}
N 70 -1130 130 -1130 {
lab=WL13}
N 70 -1150 130 -1150 {
lab=WL14}
N 70 -1170 130 -1170 {
lab=WL15}
N 60 -1160 60 -860 {bus=true
lab=WL[0..15]}
N 60 -860 60 -830 {bus=true
lab=WL[0..15]}
N 910 -870 970 -870 {
lab=WL0}
N 910 -890 970 -890 {
lab=WL1}
N 910 -910 970 -910 {
lab=WL2}
N 910 -930 970 -930 {
lab=WL3}
N 910 -950 970 -950 {
lab=WL4}
N 910 -970 970 -970 {
lab=WL5}
N 910 -990 970 -990 {
lab=WL6}
N 910 -1010 970 -1010 {
lab=WL7}
N 910 -1030 970 -1030 {
lab=WL8}
N 910 -1050 970 -1050 {
lab=WL9}
N 910 -1070 970 -1070 {
lab=WL10}
N 910 -1090 970 -1090 {
lab=WL11}
N 910 -1110 970 -1110 {
lab=WL12}
N 910 -1130 970 -1130 {
lab=WL13}
N 910 -1150 970 -1150 {
lab=WL14}
N 910 -1170 970 -1170 {
lab=WL15}
N 850 -870 910 -870 {
lab=WL0}
N 850 -890 910 -890 {
lab=WL1}
N 850 -910 910 -910 {
lab=WL2}
N 850 -930 910 -930 {
lab=WL3}
N 850 -950 910 -950 {
lab=WL4}
N 850 -970 910 -970 {
lab=WL5}
N 850 -990 910 -990 {
lab=WL6}
N 850 -1010 910 -1010 {
lab=WL7}
N 850 -1030 910 -1030 {
lab=WL8}
N 850 -1050 910 -1050 {
lab=WL9}
N 850 -1070 910 -1070 {
lab=WL10}
N 850 -1090 910 -1090 {
lab=WL11}
N 850 -1110 910 -1110 {
lab=WL12}
N 850 -1130 910 -1130 {
lab=WL13}
N 850 -1150 910 -1150 {
lab=WL14}
N 850 -1170 910 -1170 {
lab=WL15}
N 790 -870 850 -870 {
lab=WL0}
N 790 -890 850 -890 {
lab=WL1}
N 790 -910 850 -910 {
lab=WL2}
N 790 -930 850 -930 {
lab=WL3}
N 790 -950 850 -950 {
lab=WL4}
N 790 -970 850 -970 {
lab=WL5}
N 790 -990 850 -990 {
lab=WL6}
N 790 -1010 850 -1010 {
lab=WL7}
N 790 -1030 850 -1030 {
lab=WL8}
N 790 -1050 850 -1050 {
lab=WL9}
N 790 -1070 850 -1070 {
lab=WL10}
N 790 -1090 850 -1090 {
lab=WL11}
N 790 -1110 850 -1110 {
lab=WL12}
N 790 -1130 850 -1130 {
lab=WL13}
N 790 -1150 850 -1150 {
lab=WL14}
N 790 -1170 850 -1170 {
lab=WL15}
N 780 -1160 780 -860 {bus=true
lab=WL[0..15]}
N 780 -860 780 -830 {bus=true
lab=WL[0..15]}
N 1610 -860 1670 -860 {
lab=WL0}
N 1610 -880 1670 -880 {
lab=WL1}
N 1610 -900 1670 -900 {
lab=WL2}
N 1610 -920 1670 -920 {
lab=WL3}
N 1610 -940 1670 -940 {
lab=WL4}
N 1610 -960 1670 -960 {
lab=WL5}
N 1610 -980 1670 -980 {
lab=WL6}
N 1610 -1000 1670 -1000 {
lab=WL7}
N 1610 -1020 1670 -1020 {
lab=WL8}
N 1610 -1040 1670 -1040 {
lab=WL9}
N 1610 -1060 1670 -1060 {
lab=WL10}
N 1610 -1080 1670 -1080 {
lab=WL11}
N 1610 -1100 1670 -1100 {
lab=WL12}
N 1610 -1120 1670 -1120 {
lab=WL13}
N 1610 -1140 1670 -1140 {
lab=WL14}
N 1610 -1160 1670 -1160 {
lab=WL15}
N 1550 -860 1610 -860 {
lab=WL0}
N 1550 -880 1610 -880 {
lab=WL1}
N 1550 -900 1610 -900 {
lab=WL2}
N 1550 -920 1610 -920 {
lab=WL3}
N 1550 -940 1610 -940 {
lab=WL4}
N 1550 -960 1610 -960 {
lab=WL5}
N 1550 -980 1610 -980 {
lab=WL6}
N 1550 -1000 1610 -1000 {
lab=WL7}
N 1550 -1020 1610 -1020 {
lab=WL8}
N 1550 -1040 1610 -1040 {
lab=WL9}
N 1550 -1060 1610 -1060 {
lab=WL10}
N 1550 -1080 1610 -1080 {
lab=WL11}
N 1550 -1100 1610 -1100 {
lab=WL12}
N 1550 -1120 1610 -1120 {
lab=WL13}
N 1550 -1140 1610 -1140 {
lab=WL14}
N 1550 -1160 1610 -1160 {
lab=WL15}
N 1490 -860 1550 -860 {
lab=WL0}
N 1490 -880 1550 -880 {
lab=WL1}
N 1490 -900 1550 -900 {
lab=WL2}
N 1490 -920 1550 -920 {
lab=WL3}
N 1490 -940 1550 -940 {
lab=WL4}
N 1490 -960 1550 -960 {
lab=WL5}
N 1490 -980 1550 -980 {
lab=WL6}
N 1490 -1000 1550 -1000 {
lab=WL7}
N 1490 -1020 1550 -1020 {
lab=WL8}
N 1490 -1040 1550 -1040 {
lab=WL9}
N 1490 -1060 1550 -1060 {
lab=WL10}
N 1490 -1080 1550 -1080 {
lab=WL11}
N 1490 -1100 1550 -1100 {
lab=WL12}
N 1490 -1120 1550 -1120 {
lab=WL13}
N 1490 -1140 1550 -1140 {
lab=WL14}
N 1490 -1160 1550 -1160 {
lab=WL15}
N 1480 -1150 1480 -850 {bus=true
lab=WL[0..15]}
N 1480 -850 1480 -820 {bus=true
lab=WL[0..15]}
N 2340 -870 2400 -870 {
lab=WL0}
N 2340 -890 2400 -890 {
lab=WL1}
N 2340 -910 2400 -910 {
lab=WL2}
N 2340 -930 2400 -930 {
lab=WL3}
N 2340 -950 2400 -950 {
lab=WL4}
N 2340 -970 2400 -970 {
lab=WL5}
N 2340 -990 2400 -990 {
lab=WL6}
N 2340 -1010 2400 -1010 {
lab=WL7}
N 2340 -1030 2400 -1030 {
lab=WL8}
N 2340 -1050 2400 -1050 {
lab=WL9}
N 2340 -1070 2400 -1070 {
lab=WL10}
N 2340 -1090 2400 -1090 {
lab=WL11}
N 2340 -1110 2400 -1110 {
lab=WL12}
N 2340 -1130 2400 -1130 {
lab=WL13}
N 2340 -1150 2400 -1150 {
lab=WL14}
N 2340 -1170 2400 -1170 {
lab=WL15}
N 2280 -870 2340 -870 {
lab=WL0}
N 2280 -890 2340 -890 {
lab=WL1}
N 2280 -910 2340 -910 {
lab=WL2}
N 2280 -930 2340 -930 {
lab=WL3}
N 2280 -950 2340 -950 {
lab=WL4}
N 2280 -970 2340 -970 {
lab=WL5}
N 2280 -990 2340 -990 {
lab=WL6}
N 2280 -1010 2340 -1010 {
lab=WL7}
N 2280 -1030 2340 -1030 {
lab=WL8}
N 2280 -1050 2340 -1050 {
lab=WL9}
N 2280 -1070 2340 -1070 {
lab=WL10}
N 2280 -1090 2340 -1090 {
lab=WL11}
N 2280 -1110 2340 -1110 {
lab=WL12}
N 2280 -1130 2340 -1130 {
lab=WL13}
N 2280 -1150 2340 -1150 {
lab=WL14}
N 2280 -1170 2340 -1170 {
lab=WL15}
N 2220 -870 2280 -870 {
lab=WL0}
N 2220 -890 2280 -890 {
lab=WL1}
N 2220 -910 2280 -910 {
lab=WL2}
N 2220 -930 2280 -930 {
lab=WL3}
N 2220 -950 2280 -950 {
lab=WL4}
N 2220 -970 2280 -970 {
lab=WL5}
N 2220 -990 2280 -990 {
lab=WL6}
N 2220 -1010 2280 -1010 {
lab=WL7}
N 2220 -1030 2280 -1030 {
lab=WL8}
N 2220 -1050 2280 -1050 {
lab=WL9}
N 2220 -1070 2280 -1070 {
lab=WL10}
N 2220 -1090 2280 -1090 {
lab=WL11}
N 2220 -1110 2280 -1110 {
lab=WL12}
N 2220 -1130 2280 -1130 {
lab=WL13}
N 2220 -1150 2280 -1150 {
lab=WL14}
N 2220 -1170 2280 -1170 {
lab=WL15}
N 2210 -1160 2210 -860 {bus=true
lab=WL[0..15]}
N 2210 -860 2210 -830 {bus=true
lab=WL[0..15]}
N 3040 -860 3100 -860 {
lab=WL0}
N 3040 -880 3100 -880 {
lab=WL1}
N 3040 -900 3100 -900 {
lab=WL2}
N 3040 -920 3100 -920 {
lab=WL3}
N 3040 -940 3100 -940 {
lab=WL4}
N 3040 -960 3100 -960 {
lab=WL5}
N 3040 -980 3100 -980 {
lab=WL6}
N 3040 -1000 3100 -1000 {
lab=WL7}
N 3040 -1020 3100 -1020 {
lab=WL8}
N 3040 -1040 3100 -1040 {
lab=WL9}
N 3040 -1060 3100 -1060 {
lab=WL10}
N 3040 -1080 3100 -1080 {
lab=WL11}
N 3040 -1100 3100 -1100 {
lab=WL12}
N 3040 -1120 3100 -1120 {
lab=WL13}
N 3040 -1140 3100 -1140 {
lab=WL14}
N 3040 -1160 3100 -1160 {
lab=WL15}
N 2980 -860 3040 -860 {
lab=WL0}
N 2980 -880 3040 -880 {
lab=WL1}
N 2980 -900 3040 -900 {
lab=WL2}
N 2980 -920 3040 -920 {
lab=WL3}
N 2980 -940 3040 -940 {
lab=WL4}
N 2980 -960 3040 -960 {
lab=WL5}
N 2980 -980 3040 -980 {
lab=WL6}
N 2980 -1000 3040 -1000 {
lab=WL7}
N 2980 -1020 3040 -1020 {
lab=WL8}
N 2980 -1040 3040 -1040 {
lab=WL9}
N 2980 -1060 3040 -1060 {
lab=WL10}
N 2980 -1080 3040 -1080 {
lab=WL11}
N 2980 -1100 3040 -1100 {
lab=WL12}
N 2980 -1120 3040 -1120 {
lab=WL13}
N 2980 -1140 3040 -1140 {
lab=WL14}
N 2980 -1160 3040 -1160 {
lab=WL15}
N 2920 -860 2980 -860 {
lab=WL0}
N 2920 -880 2980 -880 {
lab=WL1}
N 2920 -900 2980 -900 {
lab=WL2}
N 2920 -920 2980 -920 {
lab=WL3}
N 2920 -940 2980 -940 {
lab=WL4}
N 2920 -960 2980 -960 {
lab=WL5}
N 2920 -980 2980 -980 {
lab=WL6}
N 2920 -1000 2980 -1000 {
lab=WL7}
N 2920 -1020 2980 -1020 {
lab=WL8}
N 2920 -1040 2980 -1040 {
lab=WL9}
N 2920 -1060 2980 -1060 {
lab=WL10}
N 2920 -1080 2980 -1080 {
lab=WL11}
N 2920 -1100 2980 -1100 {
lab=WL12}
N 2920 -1120 2980 -1120 {
lab=WL13}
N 2920 -1140 2980 -1140 {
lab=WL14}
N 2920 -1160 2980 -1160 {
lab=WL15}
N 2910 -1150 2910 -850 {bus=true
lab=WL[0..15]}
N 2910 -850 2910 -820 {bus=true
lab=WL[0..15]}
N 3750 -860 3810 -860 {
lab=WL0}
N 3750 -880 3810 -880 {
lab=WL1}
N 3750 -900 3810 -900 {
lab=WL2}
N 3750 -920 3810 -920 {
lab=WL3}
N 3750 -940 3810 -940 {
lab=WL4}
N 3750 -960 3810 -960 {
lab=WL5}
N 3750 -980 3810 -980 {
lab=WL6}
N 3750 -1000 3810 -1000 {
lab=WL7}
N 3750 -1020 3810 -1020 {
lab=WL8}
N 3750 -1040 3810 -1040 {
lab=WL9}
N 3750 -1060 3810 -1060 {
lab=WL10}
N 3750 -1080 3810 -1080 {
lab=WL11}
N 3750 -1100 3810 -1100 {
lab=WL12}
N 3750 -1120 3810 -1120 {
lab=WL13}
N 3750 -1140 3810 -1140 {
lab=WL14}
N 3750 -1160 3810 -1160 {
lab=WL15}
N 3690 -860 3750 -860 {
lab=WL0}
N 3690 -880 3750 -880 {
lab=WL1}
N 3690 -900 3750 -900 {
lab=WL2}
N 3690 -920 3750 -920 {
lab=WL3}
N 3690 -940 3750 -940 {
lab=WL4}
N 3690 -960 3750 -960 {
lab=WL5}
N 3690 -980 3750 -980 {
lab=WL6}
N 3690 -1000 3750 -1000 {
lab=WL7}
N 3690 -1020 3750 -1020 {
lab=WL8}
N 3690 -1040 3750 -1040 {
lab=WL9}
N 3690 -1060 3750 -1060 {
lab=WL10}
N 3690 -1080 3750 -1080 {
lab=WL11}
N 3690 -1100 3750 -1100 {
lab=WL12}
N 3690 -1120 3750 -1120 {
lab=WL13}
N 3690 -1140 3750 -1140 {
lab=WL14}
N 3690 -1160 3750 -1160 {
lab=WL15}
N 3630 -860 3690 -860 {
lab=WL0}
N 3630 -880 3690 -880 {
lab=WL1}
N 3630 -900 3690 -900 {
lab=WL2}
N 3630 -920 3690 -920 {
lab=WL3}
N 3630 -940 3690 -940 {
lab=WL4}
N 3630 -960 3690 -960 {
lab=WL5}
N 3630 -980 3690 -980 {
lab=WL6}
N 3630 -1000 3690 -1000 {
lab=WL7}
N 3630 -1020 3690 -1020 {
lab=WL8}
N 3630 -1040 3690 -1040 {
lab=WL9}
N 3630 -1060 3690 -1060 {
lab=WL10}
N 3630 -1080 3690 -1080 {
lab=WL11}
N 3630 -1100 3690 -1100 {
lab=WL12}
N 3630 -1120 3690 -1120 {
lab=WL13}
N 3630 -1140 3690 -1140 {
lab=WL14}
N 3630 -1160 3690 -1160 {
lab=WL15}
N 3620 -1150 3620 -850 {bus=true
lab=WL[0..15]}
N 3620 -850 3620 -820 {bus=true
lab=WL[0..15]}
N -770 -1370 -770 -1330 {
lab=RSEL[0..2]
bus=true}
N -770 -1650 -770 -1610 {
lab=CSEL[0..2]
bus=true}
N 40 -1210 190 -1210 {
lab=rA0}
N 40 -1250 190 -1250 {
lab=rA2}
N 40 -1270 190 -1270 {
lab=rA3}
N 40 -1290 190 -1290 {
lab=rA4}
N 40 -1310 190 -1310 {
lab=rA5}
N 40 -1330 190 -1330 {
lab=rA6}
N 40 -1350 190 -1350 {
lab=rA7}
N 40 -1370 190 -1370 {
lab=rA8}
N 40 -1410 190 -1410 {
lab=rA10}
N 40 -1390 190 -1390 {
lab=rA9}
N 40 -1430 190 -1430 {
lab=rA11}
N 40 -1450 190 -1450 {
lab=rA12}
N 40 -1470 190 -1470 {
lab=rA13}
N 40 -1490 190 -1490 {
lab=rA14}
N 40 -1510 190 -1510 {
lab=rA15}
N 190 -1710 250 -1710 {
lab=SAMPLE}
N 190 -1690 250 -1690 {
lab=Vrminus}
N 190 -1670 250 -1670 {
lab=Vrplus}
N 40 -1230 190 -1230 {
lab=rA1}
N 190 -1230 250 -1230 {
lab=rA1}
N 190 -1250 250 -1250 {
lab=rA2}
N 190 -1270 250 -1270 {
lab=rA3}
N 190 -1290 250 -1290 {
lab=rA4}
N 190 -1310 250 -1310 {
lab=rA5}
N 190 -1330 250 -1330 {
lab=rA6}
N 190 -1350 250 -1350 {
lab=rA7}
N 190 -1370 250 -1370 {
lab=rA8}
N 190 -1390 250 -1390 {
lab=rA9}
N 190 -1410 250 -1410 {
lab=rA10}
N 190 -1430 250 -1430 {
lab=rA11}
N 190 -1450 250 -1450 {
lab=rA12}
N 190 -1470 250 -1470 {
lab=rA13}
N 190 -1490 250 -1490 {
lab=rA14}
N 190 -1510 250 -1510 {
lab=rA15}
N 30 -1500 30 -1160 {
lab=rA[0..15]
bus=true}
N 550 -1210 600 -1210 {
lab=rB0}
N 550 -1230 600 -1230 {
lab=rB1}
N 670 -1220 670 -1160 {
lab=rB[0..15]
bus=true}
N 550 -1250 600 -1250 {
lab=rB2}
N 550 -1270 600 -1270 {
lab=rB3}
N 550 -1290 600 -1290 {
lab=rB4}
N 550 -1310 600 -1310 {
lab=rB5}
N 550 -1330 600 -1330 {
lab=rB6}
N 550 -1350 600 -1350 {
lab=rB7}
N 550 -1370 600 -1370 {
lab=rB8}
N 550 -1390 600 -1390 {
lab=rB9}
N 550 -1410 600 -1410 {
lab=rB10}
N 550 -1430 600 -1430 {
lab=rB11}
N 550 -1450 600 -1450 {
lab=rB12}
N 550 -1470 600 -1470 {
lab=rB13}
N 550 -1490 600 -1490 {
lab=rB14}
N 550 -1510 600 -1510 {
lab=rB15}
N 670 -1500 670 -1220 {
lab=rB[0..15]
bus=true}
N 180 -820 180 -520 {bus=true
lab=cA[0..15]}
N 180 -520 180 -490 {bus=true
lab=cA[0..15]}
N 550 -530 610 -530 {
lab=cB0}
N 550 -550 610 -550 {
lab=cB1}
N 550 -570 610 -570 {
lab=cB2}
N 550 -590 610 -590 {
lab=cB3}
N 550 -610 610 -610 {
lab=cB4}
N 550 -630 610 -630 {
lab=cB5}
N 550 -650 610 -650 {
lab=cB6}
N 550 -670 610 -670 {
lab=cB7}
N 550 -690 610 -690 {
lab=cB8}
N 550 -710 610 -710 {
lab=cB9}
N 550 -730 610 -730 {
lab=cB10}
N 550 -750 610 -750 {
lab=cB11}
N 550 -770 610 -770 {
lab=cB12}
N 550 -790 610 -790 {
lab=cB13}
N 550 -810 610 -810 {
lab=cB14}
N 550 -830 610 -830 {
lab=cB15}
N 620 -820 620 -520 {bus=true
lab=cB[0..15]}
N 620 -520 620 -490 {bus=true
lab=cB[0..15]}
N 910 -1210 970 -1210 {
lab=rA0}
N 1320 -1210 1380 -1210 {
lab=rB0}
N 1320 -1230 1380 -1230 {
lab=rB1}
N 1320 -1250 1380 -1250 {
lab=rB2}
N 1320 -1270 1380 -1270 {
lab=rB3}
N 1320 -1290 1380 -1290 {
lab=rB4}
N 1320 -1310 1380 -1310 {
lab=rB5}
N 1320 -1330 1380 -1330 {
lab=rB6}
N 1320 -1350 1380 -1350 {
lab=rB7}
N 1320 -1370 1380 -1370 {
lab=rB8}
N 1320 -1390 1380 -1390 {
lab=rB9}
N 1320 -1410 1380 -1410 {
lab=rB10}
N 1320 -1430 1380 -1430 {
lab=rB11}
N 1320 -1450 1380 -1450 {
lab=rB12}
N 1320 -1470 1380 -1470 {
lab=rB13}
N 1320 -1490 1380 -1490 {
lab=rB14}
N 1320 -1510 1380 -1510 {
lab=rB15}
N 910 -1790 970 -1790 {
lab=col1_sel}
N 910 -1810 970 -1810 {
lab=row0_sel}
N 910 -1570 970 -1570 {
lab=Vcplus}
N 910 -1590 970 -1590 {
lab=Vcminus}
N 910 -1610 970 -1610 {
lab=Vref}
N 910 -1630 970 -1630 {
lab=Vref_comp}
N 910 -1650 970 -1650 {
lab=RISC_CLK}
N 1270 -1750 1330 -1750 {
lab=vssd1}
N 1270 -1770 1330 -1770 {
lab=vdda1}
N 1270 -1790 1330 -1790 {
lab=vccd1}
N 1270 -1810 1330 -1810 {
lab=latch_high1}
N 760 -1210 910 -1210 {
lab=rA0}
N 760 -1250 910 -1250 {
lab=rA2}
N 760 -1270 910 -1270 {
lab=rA3}
N 760 -1290 910 -1290 {
lab=rA4}
N 760 -1310 910 -1310 {
lab=rA5}
N 760 -1330 910 -1330 {
lab=rA6}
N 760 -1350 910 -1350 {
lab=rA7}
N 760 -1370 910 -1370 {
lab=rA8}
N 760 -1410 910 -1410 {
lab=rA10}
N 760 -1390 910 -1390 {
lab=rA9}
N 760 -1430 910 -1430 {
lab=rA11}
N 760 -1450 910 -1450 {
lab=rA12}
N 760 -1470 910 -1470 {
lab=rA13}
N 760 -1490 910 -1490 {
lab=rA14}
N 760 -1510 910 -1510 {
lab=rA15}
N 910 -1710 970 -1710 {
lab=SAMPLE}
N 910 -1690 970 -1690 {
lab=Vrminus}
N 910 -1670 970 -1670 {
lab=Vrplus}
N 760 -1230 910 -1230 {
lab=rA1}
N 910 -1230 970 -1230 {
lab=rA1}
N 910 -1250 970 -1250 {
lab=rA2}
N 910 -1270 970 -1270 {
lab=rA3}
N 910 -1290 970 -1290 {
lab=rA4}
N 910 -1310 970 -1310 {
lab=rA5}
N 910 -1330 970 -1330 {
lab=rA6}
N 910 -1350 970 -1350 {
lab=rA7}
N 910 -1370 970 -1370 {
lab=rA8}
N 910 -1390 970 -1390 {
lab=rA9}
N 910 -1410 970 -1410 {
lab=rA10}
N 910 -1430 970 -1430 {
lab=rA11}
N 910 -1450 970 -1450 {
lab=rA12}
N 910 -1470 970 -1470 {
lab=rA13}
N 910 -1490 970 -1490 {
lab=rA14}
N 910 -1510 970 -1510 {
lab=rA15}
N 750 -1500 750 -1160 {
lab=rA[0..15]
bus=true}
N 1270 -1210 1320 -1210 {
lab=rB0}
N 1270 -1230 1320 -1230 {
lab=rB1}
N 1390 -1220 1390 -1160 {
lab=rB[0..15]
bus=true}
N 1270 -1250 1320 -1250 {
lab=rB2}
N 1270 -1270 1320 -1270 {
lab=rB3}
N 1270 -1290 1320 -1290 {
lab=rB4}
N 1270 -1310 1320 -1310 {
lab=rB5}
N 1270 -1330 1320 -1330 {
lab=rB6}
N 1270 -1350 1320 -1350 {
lab=rB7}
N 1270 -1370 1320 -1370 {
lab=rB8}
N 1270 -1390 1320 -1390 {
lab=rB9}
N 1270 -1410 1320 -1410 {
lab=rB10}
N 1270 -1430 1320 -1430 {
lab=rB11}
N 1270 -1450 1320 -1450 {
lab=rB12}
N 1270 -1470 1320 -1470 {
lab=rB13}
N 1270 -1490 1320 -1490 {
lab=rB14}
N 1270 -1510 1320 -1510 {
lab=rB15}
N 1390 -1500 1390 -1220 {
lab=rB[0..15]
bus=true}
N 910 -1750 970 -1750 {
lab=WR}
N 910 -1770 970 -1770 {
lab=Vgnr}
N 910 -1730 970 -1730 {
lab=Vgpr}
N 1610 -1780 1670 -1780 {
lab=col2_sel}
N 1610 -1800 1670 -1800 {
lab=row0_sel}
N 1610 -1560 1670 -1560 {
lab=Vcplus}
N 1610 -1580 1670 -1580 {
lab=Vcminus}
N 1610 -1600 1670 -1600 {
lab=Vref}
N 1610 -1620 1670 -1620 {
lab=Vref_comp}
N 1610 -1640 1670 -1640 {
lab=RISC_CLK}
N 1610 -1700 1670 -1700 {
lab=SAMPLE}
N 1610 -1680 1670 -1680 {
lab=Vrminus}
N 1610 -1660 1670 -1660 {
lab=Vrplus}
N 1610 -1740 1670 -1740 {
lab=WR}
N 1610 -1760 1670 -1760 {
lab=Vgnr}
N 1610 -1720 1670 -1720 {
lab=Vgpr}
N 1970 -1740 2030 -1740 {
lab=vssd1}
N 1970 -1760 2030 -1760 {
lab=vdda1}
N 1970 -1780 2030 -1780 {
lab=vccd1}
N 1610 -1200 1670 -1200 {
lab=rA0}
N 2020 -1200 2080 -1200 {
lab=rB0}
N 2020 -1220 2080 -1220 {
lab=rB1}
N 2020 -1240 2080 -1240 {
lab=rB2}
N 2020 -1260 2080 -1260 {
lab=rB3}
N 2020 -1280 2080 -1280 {
lab=rB4}
N 2020 -1300 2080 -1300 {
lab=rB5}
N 2020 -1320 2080 -1320 {
lab=rB6}
N 2020 -1340 2080 -1340 {
lab=rB7}
N 2020 -1360 2080 -1360 {
lab=rB8}
N 2020 -1380 2080 -1380 {
lab=rB9}
N 2020 -1400 2080 -1400 {
lab=rB10}
N 2020 -1420 2080 -1420 {
lab=rB11}
N 2020 -1440 2080 -1440 {
lab=rB12}
N 2020 -1460 2080 -1460 {
lab=rB13}
N 2020 -1480 2080 -1480 {
lab=rB14}
N 2020 -1500 2080 -1500 {
lab=rB15}
N 1460 -1200 1610 -1200 {
lab=rA0}
N 1460 -1240 1610 -1240 {
lab=rA2}
N 1460 -1260 1610 -1260 {
lab=rA3}
N 1460 -1280 1610 -1280 {
lab=rA4}
N 1460 -1300 1610 -1300 {
lab=rA5}
N 1460 -1320 1610 -1320 {
lab=rA6}
N 1460 -1340 1610 -1340 {
lab=rA7}
N 1460 -1360 1610 -1360 {
lab=rA8}
N 1460 -1400 1610 -1400 {
lab=rA10}
N 1460 -1380 1610 -1380 {
lab=rA9}
N 1460 -1420 1610 -1420 {
lab=rA11}
N 1460 -1440 1610 -1440 {
lab=rA12}
N 1460 -1460 1610 -1460 {
lab=rA13}
N 1460 -1480 1610 -1480 {
lab=rA14}
N 1460 -1500 1610 -1500 {
lab=rA15}
N 1460 -1220 1610 -1220 {
lab=rA1}
N 1610 -1220 1670 -1220 {
lab=rA1}
N 1610 -1240 1670 -1240 {
lab=rA2}
N 1610 -1260 1670 -1260 {
lab=rA3}
N 1610 -1280 1670 -1280 {
lab=rA4}
N 1610 -1300 1670 -1300 {
lab=rA5}
N 1610 -1320 1670 -1320 {
lab=rA6}
N 1610 -1340 1670 -1340 {
lab=rA7}
N 1610 -1360 1670 -1360 {
lab=rA8}
N 1610 -1380 1670 -1380 {
lab=rA9}
N 1610 -1400 1670 -1400 {
lab=rA10}
N 1610 -1420 1670 -1420 {
lab=rA11}
N 1610 -1440 1670 -1440 {
lab=rA12}
N 1610 -1460 1670 -1460 {
lab=rA13}
N 1610 -1480 1670 -1480 {
lab=rA14}
N 1610 -1500 1670 -1500 {
lab=rA15}
N 1450 -1490 1450 -1150 {
lab=rA[0..15]
bus=true}
N 1970 -1200 2020 -1200 {
lab=rB0}
N 1970 -1220 2020 -1220 {
lab=rB1}
N 2090 -1210 2090 -1150 {
lab=rB[0..15]
bus=true}
N 1970 -1240 2020 -1240 {
lab=rB2}
N 1970 -1260 2020 -1260 {
lab=rB3}
N 1970 -1280 2020 -1280 {
lab=rB4}
N 1970 -1300 2020 -1300 {
lab=rB5}
N 1970 -1320 2020 -1320 {
lab=rB6}
N 1970 -1340 2020 -1340 {
lab=rB7}
N 1970 -1360 2020 -1360 {
lab=rB8}
N 1970 -1380 2020 -1380 {
lab=rB9}
N 1970 -1400 2020 -1400 {
lab=rB10}
N 1970 -1420 2020 -1420 {
lab=rB11}
N 1970 -1440 2020 -1440 {
lab=rB12}
N 1970 -1460 2020 -1460 {
lab=rB13}
N 1970 -1480 2020 -1480 {
lab=rB14}
N 1970 -1500 2020 -1500 {
lab=rB15}
N 2090 -1490 2090 -1210 {
lab=rB[0..15]
bus=true}
N 910 -530 970 -530 {
lab=cA0}
N 910 -550 970 -550 {
lab=cA1}
N 910 -570 970 -570 {
lab=cA2}
N 910 -590 970 -590 {
lab=cA3}
N 910 -610 970 -610 {
lab=cA4}
N 910 -630 970 -630 {
lab=cA5}
N 910 -650 970 -650 {
lab=cA6}
N 910 -670 970 -670 {
lab=cA7}
N 910 -690 970 -690 {
lab=cA8}
N 910 -710 970 -710 {
lab=cA9}
N 910 -730 970 -730 {
lab=cA10}
N 910 -750 970 -750 {
lab=cA11}
N 910 -770 970 -770 {
lab=cA12}
N 910 -790 970 -790 {
lab=cA13}
N 910 -810 970 -810 {
lab=cA14}
N 910 -830 970 -830 {
lab=cA15}
N 900 -820 900 -520 {bus=true
lab=cA[0..15]}
N 900 -520 900 -490 {bus=true
lab=cA[0..15]}
N 1270 -530 1330 -530 {
lab=cB0}
N 1270 -550 1330 -550 {
lab=cB1}
N 1270 -570 1330 -570 {
lab=cB2}
N 1270 -590 1330 -590 {
lab=cB3}
N 1270 -610 1330 -610 {
lab=cB4}
N 1270 -630 1330 -630 {
lab=cB5}
N 1270 -650 1330 -650 {
lab=cB6}
N 1270 -670 1330 -670 {
lab=cB7}
N 1270 -690 1330 -690 {
lab=cB8}
N 1270 -710 1330 -710 {
lab=cB9}
N 1270 -730 1330 -730 {
lab=cB10}
N 1270 -750 1330 -750 {
lab=cB11}
N 1270 -770 1330 -770 {
lab=cB12}
N 1270 -790 1330 -790 {
lab=cB13}
N 1270 -810 1330 -810 {
lab=cB14}
N 1270 -830 1330 -830 {
lab=cB15}
N 1340 -820 1340 -520 {bus=true
lab=cB[0..15]}
N 1340 -520 1340 -490 {bus=true
lab=cB[0..15]}
N 1610 -520 1670 -520 {
lab=cA0}
N 1610 -540 1670 -540 {
lab=cA1}
N 1610 -560 1670 -560 {
lab=cA2}
N 1610 -580 1670 -580 {
lab=cA3}
N 1610 -600 1670 -600 {
lab=cA4}
N 1610 -620 1670 -620 {
lab=cA5}
N 1610 -640 1670 -640 {
lab=cA6}
N 1610 -660 1670 -660 {
lab=cA7}
N 1610 -680 1670 -680 {
lab=cA8}
N 1610 -700 1670 -700 {
lab=cA9}
N 1610 -720 1670 -720 {
lab=cA10}
N 1610 -740 1670 -740 {
lab=cA11}
N 1610 -760 1670 -760 {
lab=cA12}
N 1610 -780 1670 -780 {
lab=cA13}
N 1610 -800 1670 -800 {
lab=cA14}
N 1610 -820 1670 -820 {
lab=cA15}
N 1600 -810 1600 -510 {bus=true
lab=cA[0..15]}
N 1600 -510 1600 -480 {bus=true
lab=cA[0..15]}
N 1970 -520 2030 -520 {
lab=cB0}
N 1970 -540 2030 -540 {
lab=cB1}
N 1970 -560 2030 -560 {
lab=cB2}
N 1970 -580 2030 -580 {
lab=cB3}
N 1970 -600 2030 -600 {
lab=cB4}
N 1970 -620 2030 -620 {
lab=cB5}
N 1970 -640 2030 -640 {
lab=cB6}
N 1970 -660 2030 -660 {
lab=cB7}
N 1970 -680 2030 -680 {
lab=cB8}
N 1970 -700 2030 -700 {
lab=cB9}
N 1970 -720 2030 -720 {
lab=cB10}
N 1970 -740 2030 -740 {
lab=cB11}
N 1970 -760 2030 -760 {
lab=cB12}
N 1970 -780 2030 -780 {
lab=cB13}
N 1970 -800 2030 -800 {
lab=cB14}
N 1970 -820 2030 -820 {
lab=cB15}
N 2040 -810 2040 -510 {bus=true
lab=cB[0..15]}
N 2040 -510 2040 -480 {bus=true
lab=cB[0..15]}
N 2340 -1210 2400 -1210 {
lab=rA0}
N 2750 -1210 2810 -1210 {
lab=rB0}
N 2750 -1230 2810 -1230 {
lab=rB1}
N 2750 -1250 2810 -1250 {
lab=rB2}
N 2750 -1270 2810 -1270 {
lab=rB3}
N 2750 -1290 2810 -1290 {
lab=rB4}
N 2750 -1310 2810 -1310 {
lab=rB5}
N 2750 -1330 2810 -1330 {
lab=rB6}
N 2750 -1350 2810 -1350 {
lab=rB7}
N 2750 -1370 2810 -1370 {
lab=rB8}
N 2750 -1390 2810 -1390 {
lab=rB9}
N 2750 -1410 2810 -1410 {
lab=rB10}
N 2750 -1430 2810 -1430 {
lab=rB11}
N 2750 -1450 2810 -1450 {
lab=rB12}
N 2750 -1470 2810 -1470 {
lab=rB13}
N 2750 -1490 2810 -1490 {
lab=rB14}
N 2750 -1510 2810 -1510 {
lab=rB15}
N 2190 -1210 2340 -1210 {
lab=rA0}
N 2190 -1250 2340 -1250 {
lab=rA2}
N 2190 -1270 2340 -1270 {
lab=rA3}
N 2190 -1290 2340 -1290 {
lab=rA4}
N 2190 -1310 2340 -1310 {
lab=rA5}
N 2190 -1330 2340 -1330 {
lab=rA6}
N 2190 -1350 2340 -1350 {
lab=rA7}
N 2190 -1370 2340 -1370 {
lab=rA8}
N 2190 -1410 2340 -1410 {
lab=rA10}
N 2190 -1390 2340 -1390 {
lab=rA9}
N 2190 -1430 2340 -1430 {
lab=rA11}
N 2190 -1450 2340 -1450 {
lab=rA12}
N 2190 -1470 2340 -1470 {
lab=rA13}
N 2190 -1490 2340 -1490 {
lab=rA14}
N 2190 -1510 2340 -1510 {
lab=rA15}
N 2190 -1230 2340 -1230 {
lab=rA1}
N 2340 -1230 2400 -1230 {
lab=rA1}
N 2340 -1250 2400 -1250 {
lab=rA2}
N 2340 -1270 2400 -1270 {
lab=rA3}
N 2340 -1290 2400 -1290 {
lab=rA4}
N 2340 -1310 2400 -1310 {
lab=rA5}
N 2340 -1330 2400 -1330 {
lab=rA6}
N 2340 -1350 2400 -1350 {
lab=rA7}
N 2340 -1370 2400 -1370 {
lab=rA8}
N 2340 -1390 2400 -1390 {
lab=rA9}
N 2340 -1410 2400 -1410 {
lab=rA10}
N 2340 -1430 2400 -1430 {
lab=rA11}
N 2340 -1450 2400 -1450 {
lab=rA12}
N 2340 -1470 2400 -1470 {
lab=rA13}
N 2340 -1490 2400 -1490 {
lab=rA14}
N 2340 -1510 2400 -1510 {
lab=rA15}
N 2180 -1500 2180 -1160 {
lab=rA[0..15]
bus=true}
N 2700 -1210 2750 -1210 {
lab=rB0}
N 2700 -1230 2750 -1230 {
lab=rB1}
N 2820 -1220 2820 -1160 {
lab=rB[0..15]
bus=true}
N 2700 -1250 2750 -1250 {
lab=rB2}
N 2700 -1270 2750 -1270 {
lab=rB3}
N 2700 -1290 2750 -1290 {
lab=rB4}
N 2700 -1310 2750 -1310 {
lab=rB5}
N 2700 -1330 2750 -1330 {
lab=rB6}
N 2700 -1350 2750 -1350 {
lab=rB7}
N 2700 -1370 2750 -1370 {
lab=rB8}
N 2700 -1390 2750 -1390 {
lab=rB9}
N 2700 -1410 2750 -1410 {
lab=rB10}
N 2700 -1430 2750 -1430 {
lab=rB11}
N 2700 -1450 2750 -1450 {
lab=rB12}
N 2700 -1470 2750 -1470 {
lab=rB13}
N 2700 -1490 2750 -1490 {
lab=rB14}
N 2700 -1510 2750 -1510 {
lab=rB15}
N 2820 -1500 2820 -1220 {
lab=rB[0..15]
bus=true}
N 2340 -530 2400 -530 {
lab=cA0}
N 2340 -550 2400 -550 {
lab=cA1}
N 2340 -570 2400 -570 {
lab=cA2}
N 2340 -590 2400 -590 {
lab=cA3}
N 2340 -610 2400 -610 {
lab=cA4}
N 2340 -630 2400 -630 {
lab=cA5}
N 2340 -650 2400 -650 {
lab=cA6}
N 2340 -670 2400 -670 {
lab=cA7}
N 2340 -690 2400 -690 {
lab=cA8}
N 2340 -710 2400 -710 {
lab=cA9}
N 2340 -730 2400 -730 {
lab=cA10}
N 2340 -750 2400 -750 {
lab=cA11}
N 2340 -770 2400 -770 {
lab=cA12}
N 2340 -790 2400 -790 {
lab=cA13}
N 2340 -810 2400 -810 {
lab=cA14}
N 2340 -830 2400 -830 {
lab=cA15}
N 2330 -820 2330 -520 {bus=true
lab=cA[0..15]}
N 2330 -520 2330 -490 {bus=true
lab=cA[0..15]}
N 2700 -530 2760 -530 {
lab=cB0}
N 2700 -550 2760 -550 {
lab=cB1}
N 2700 -570 2760 -570 {
lab=cB2}
N 2700 -590 2760 -590 {
lab=cB3}
N 2700 -610 2760 -610 {
lab=cB4}
N 2700 -630 2760 -630 {
lab=cB5}
N 2700 -650 2760 -650 {
lab=cB6}
N 2700 -670 2760 -670 {
lab=cB7}
N 2700 -690 2760 -690 {
lab=cB8}
N 2700 -710 2760 -710 {
lab=cB9}
N 2700 -730 2760 -730 {
lab=cB10}
N 2700 -750 2760 -750 {
lab=cB11}
N 2700 -770 2760 -770 {
lab=cB12}
N 2700 -790 2760 -790 {
lab=cB13}
N 2700 -810 2760 -810 {
lab=cB14}
N 2700 -830 2760 -830 {
lab=cB15}
N 2770 -820 2770 -520 {bus=true
lab=cB[0..15]}
N 2770 -520 2770 -490 {bus=true
lab=cB[0..15]}
N 3040 -1200 3100 -1200 {
lab=rA0}
N 3450 -1200 3510 -1200 {
lab=rB0}
N 3450 -1220 3510 -1220 {
lab=rB1}
N 3450 -1240 3510 -1240 {
lab=rB2}
N 3450 -1260 3510 -1260 {
lab=rB3}
N 3450 -1280 3510 -1280 {
lab=rB4}
N 3450 -1300 3510 -1300 {
lab=rB5}
N 3450 -1320 3510 -1320 {
lab=rB6}
N 3450 -1340 3510 -1340 {
lab=rB7}
N 3450 -1360 3510 -1360 {
lab=rB8}
N 3450 -1380 3510 -1380 {
lab=rB9}
N 3450 -1400 3510 -1400 {
lab=rB10}
N 3450 -1420 3510 -1420 {
lab=rB11}
N 3450 -1440 3510 -1440 {
lab=rB12}
N 3450 -1460 3510 -1460 {
lab=rB13}
N 3450 -1480 3510 -1480 {
lab=rB14}
N 3450 -1500 3510 -1500 {
lab=rB15}
N 2890 -1200 3040 -1200 {
lab=rA0}
N 2890 -1240 3040 -1240 {
lab=rA2}
N 2890 -1260 3040 -1260 {
lab=rA3}
N 2890 -1280 3040 -1280 {
lab=rA4}
N 2890 -1300 3040 -1300 {
lab=rA5}
N 2890 -1320 3040 -1320 {
lab=rA6}
N 2890 -1340 3040 -1340 {
lab=rA7}
N 2890 -1360 3040 -1360 {
lab=rA8}
N 2890 -1400 3040 -1400 {
lab=rA10}
N 2890 -1380 3040 -1380 {
lab=rA9}
N 2890 -1420 3040 -1420 {
lab=rA11}
N 2890 -1440 3040 -1440 {
lab=rA12}
N 2890 -1460 3040 -1460 {
lab=rA13}
N 2890 -1480 3040 -1480 {
lab=rA14}
N 2890 -1500 3040 -1500 {
lab=rA15}
N 2890 -1220 3040 -1220 {
lab=rA1}
N 3040 -1220 3100 -1220 {
lab=rA1}
N 3040 -1240 3100 -1240 {
lab=rA2}
N 3040 -1260 3100 -1260 {
lab=rA3}
N 3040 -1280 3100 -1280 {
lab=rA4}
N 3040 -1300 3100 -1300 {
lab=rA5}
N 3040 -1320 3100 -1320 {
lab=rA6}
N 3040 -1340 3100 -1340 {
lab=rA7}
N 3040 -1360 3100 -1360 {
lab=rA8}
N 3040 -1380 3100 -1380 {
lab=rA9}
N 3040 -1400 3100 -1400 {
lab=rA10}
N 3040 -1420 3100 -1420 {
lab=rA11}
N 3040 -1440 3100 -1440 {
lab=rA12}
N 3040 -1460 3100 -1460 {
lab=rA13}
N 3040 -1480 3100 -1480 {
lab=rA14}
N 3040 -1500 3100 -1500 {
lab=rA15}
N 2880 -1490 2880 -1150 {
lab=rA[0..15]
bus=true}
N 3400 -1200 3450 -1200 {
lab=rB0}
N 3400 -1220 3450 -1220 {
lab=rB1}
N 3520 -1210 3520 -1150 {
lab=rB[0..15]
bus=true}
N 3400 -1240 3450 -1240 {
lab=rB2}
N 3400 -1260 3450 -1260 {
lab=rB3}
N 3400 -1280 3450 -1280 {
lab=rB4}
N 3400 -1300 3450 -1300 {
lab=rB5}
N 3400 -1320 3450 -1320 {
lab=rB6}
N 3400 -1340 3450 -1340 {
lab=rB7}
N 3400 -1360 3450 -1360 {
lab=rB8}
N 3400 -1380 3450 -1380 {
lab=rB9}
N 3400 -1400 3450 -1400 {
lab=rB10}
N 3400 -1420 3450 -1420 {
lab=rB11}
N 3400 -1440 3450 -1440 {
lab=rB12}
N 3400 -1460 3450 -1460 {
lab=rB13}
N 3400 -1480 3450 -1480 {
lab=rB14}
N 3400 -1500 3450 -1500 {
lab=rB15}
N 3520 -1490 3520 -1210 {
lab=rB[0..15]
bus=true}
N 3040 -520 3100 -520 {
lab=cA0}
N 3040 -540 3100 -540 {
lab=cA1}
N 3040 -560 3100 -560 {
lab=cA2}
N 3040 -580 3100 -580 {
lab=cA3}
N 3040 -600 3100 -600 {
lab=cA4}
N 3040 -620 3100 -620 {
lab=cA5}
N 3040 -640 3100 -640 {
lab=cA6}
N 3040 -660 3100 -660 {
lab=cA7}
N 3040 -680 3100 -680 {
lab=cA8}
N 3040 -700 3100 -700 {
lab=cA9}
N 3040 -720 3100 -720 {
lab=cA10}
N 3040 -740 3100 -740 {
lab=cA11}
N 3040 -760 3100 -760 {
lab=cA12}
N 3040 -780 3100 -780 {
lab=cA13}
N 3040 -800 3100 -800 {
lab=cA14}
N 3040 -820 3100 -820 {
lab=cA15}
N 3030 -810 3030 -510 {bus=true
lab=cA[0..15]}
N 3030 -510 3030 -480 {bus=true
lab=cA[0..15]}
N 3400 -520 3460 -520 {
lab=cB0}
N 3400 -540 3460 -540 {
lab=cB1}
N 3400 -560 3460 -560 {
lab=cB2}
N 3400 -580 3460 -580 {
lab=cB3}
N 3400 -600 3460 -600 {
lab=cB4}
N 3400 -620 3460 -620 {
lab=cB5}
N 3400 -640 3460 -640 {
lab=cB6}
N 3400 -660 3460 -660 {
lab=cB7}
N 3400 -680 3460 -680 {
lab=cB8}
N 3400 -700 3460 -700 {
lab=cB9}
N 3400 -720 3460 -720 {
lab=cB10}
N 3400 -740 3460 -740 {
lab=cB11}
N 3400 -760 3460 -760 {
lab=cB12}
N 3400 -780 3460 -780 {
lab=cB13}
N 3400 -800 3460 -800 {
lab=cB14}
N 3400 -820 3460 -820 {
lab=cB15}
N 3470 -810 3470 -510 {bus=true
lab=cB[0..15]}
N 3470 -510 3470 -480 {bus=true
lab=cB[0..15]}
N 3750 -1200 3810 -1200 {
lab=rA0}
N 4160 -1200 4220 -1200 {
lab=rB0}
N 4160 -1220 4220 -1220 {
lab=rB1}
N 4160 -1240 4220 -1240 {
lab=rB2}
N 4160 -1260 4220 -1260 {
lab=rB3}
N 4160 -1280 4220 -1280 {
lab=rB4}
N 4160 -1300 4220 -1300 {
lab=rB5}
N 4160 -1320 4220 -1320 {
lab=rB6}
N 4160 -1340 4220 -1340 {
lab=rB7}
N 4160 -1360 4220 -1360 {
lab=rB8}
N 4160 -1380 4220 -1380 {
lab=rB9}
N 4160 -1400 4220 -1400 {
lab=rB10}
N 4160 -1420 4220 -1420 {
lab=rB11}
N 4160 -1440 4220 -1440 {
lab=rB12}
N 4160 -1460 4220 -1460 {
lab=rB13}
N 4160 -1480 4220 -1480 {
lab=rB14}
N 4160 -1500 4220 -1500 {
lab=rB15}
N 3600 -1200 3750 -1200 {
lab=rA0}
N 3600 -1240 3750 -1240 {
lab=rA2}
N 3600 -1260 3750 -1260 {
lab=rA3}
N 3600 -1280 3750 -1280 {
lab=rA4}
N 3600 -1300 3750 -1300 {
lab=rA5}
N 3600 -1320 3750 -1320 {
lab=rA6}
N 3600 -1340 3750 -1340 {
lab=rA7}
N 3600 -1360 3750 -1360 {
lab=rA8}
N 3600 -1400 3750 -1400 {
lab=rA10}
N 3600 -1380 3750 -1380 {
lab=rA9}
N 3600 -1420 3750 -1420 {
lab=rA11}
N 3600 -1440 3750 -1440 {
lab=rA12}
N 3600 -1460 3750 -1460 {
lab=rA13}
N 3600 -1480 3750 -1480 {
lab=rA14}
N 3600 -1500 3750 -1500 {
lab=rA15}
N 3600 -1220 3750 -1220 {
lab=rA1}
N 3750 -1220 3810 -1220 {
lab=rA1}
N 3750 -1240 3810 -1240 {
lab=rA2}
N 3750 -1260 3810 -1260 {
lab=rA3}
N 3750 -1280 3810 -1280 {
lab=rA4}
N 3750 -1300 3810 -1300 {
lab=rA5}
N 3750 -1320 3810 -1320 {
lab=rA6}
N 3750 -1340 3810 -1340 {
lab=rA7}
N 3750 -1360 3810 -1360 {
lab=rA8}
N 3750 -1380 3810 -1380 {
lab=rA9}
N 3750 -1400 3810 -1400 {
lab=rA10}
N 3750 -1420 3810 -1420 {
lab=rA11}
N 3750 -1440 3810 -1440 {
lab=rA12}
N 3750 -1460 3810 -1460 {
lab=rA13}
N 3750 -1480 3810 -1480 {
lab=rA14}
N 3750 -1500 3810 -1500 {
lab=rA15}
N 3590 -1490 3590 -1150 {
lab=rA[0..15]
bus=true}
N 4110 -1200 4160 -1200 {
lab=rB0}
N 4110 -1220 4160 -1220 {
lab=rB1}
N 4230 -1210 4230 -1150 {
lab=rB[0..15]
bus=true}
N 4110 -1240 4160 -1240 {
lab=rB2}
N 4110 -1260 4160 -1260 {
lab=rB3}
N 4110 -1280 4160 -1280 {
lab=rB4}
N 4110 -1300 4160 -1300 {
lab=rB5}
N 4110 -1320 4160 -1320 {
lab=rB6}
N 4110 -1340 4160 -1340 {
lab=rB7}
N 4110 -1360 4160 -1360 {
lab=rB8}
N 4110 -1380 4160 -1380 {
lab=rB9}
N 4110 -1400 4160 -1400 {
lab=rB10}
N 4110 -1420 4160 -1420 {
lab=rB11}
N 4110 -1440 4160 -1440 {
lab=rB12}
N 4110 -1460 4160 -1460 {
lab=rB13}
N 4110 -1480 4160 -1480 {
lab=rB14}
N 4110 -1500 4160 -1500 {
lab=rB15}
N 4230 -1490 4230 -1210 {
lab=rB[0..15]
bus=true}
N 3750 -520 3810 -520 {
lab=cA0}
N 3750 -540 3810 -540 {
lab=cA1}
N 3750 -560 3810 -560 {
lab=cA2}
N 3750 -580 3810 -580 {
lab=cA3}
N 3750 -600 3810 -600 {
lab=cA4}
N 3750 -620 3810 -620 {
lab=cA5}
N 3750 -640 3810 -640 {
lab=cA6}
N 3750 -660 3810 -660 {
lab=cA7}
N 3750 -680 3810 -680 {
lab=cA8}
N 3750 -700 3810 -700 {
lab=cA9}
N 3750 -720 3810 -720 {
lab=cA10}
N 3750 -740 3810 -740 {
lab=cA11}
N 3750 -760 3810 -760 {
lab=cA12}
N 3750 -780 3810 -780 {
lab=cA13}
N 3750 -800 3810 -800 {
lab=cA14}
N 3750 -820 3810 -820 {
lab=cA15}
N 3740 -810 3740 -510 {bus=true
lab=cA[0..15]}
N 3740 -510 3740 -480 {bus=true
lab=cA[0..15]}
N 4110 -520 4170 -520 {
lab=cB0}
N 4110 -540 4170 -540 {
lab=cB1}
N 4110 -560 4170 -560 {
lab=cB2}
N 4110 -580 4170 -580 {
lab=cB3}
N 4110 -600 4170 -600 {
lab=cB4}
N 4110 -620 4170 -620 {
lab=cB5}
N 4110 -640 4170 -640 {
lab=cB6}
N 4110 -660 4170 -660 {
lab=cB7}
N 4110 -680 4170 -680 {
lab=cB8}
N 4110 -700 4170 -700 {
lab=cB9}
N 4110 -720 4170 -720 {
lab=cB10}
N 4110 -740 4170 -740 {
lab=cB11}
N 4110 -760 4170 -760 {
lab=cB12}
N 4110 -780 4170 -780 {
lab=cB13}
N 4110 -800 4170 -800 {
lab=cB14}
N 4110 -820 4170 -820 {
lab=cB15}
N 4180 -810 4180 -510 {bus=true
lab=cB[0..15]}
N 4180 -510 4180 -480 {bus=true
lab=cB[0..15]}
N 2340 -1790 2400 -1790 {
lab=col3_sel}
N 2340 -1810 2400 -1810 {
lab=row0_sel}
N 2340 -1570 2400 -1570 {
lab=Vcplus}
N 2340 -1590 2400 -1590 {
lab=Vcminus}
N 2340 -1610 2400 -1610 {
lab=Vref}
N 2340 -1630 2400 -1630 {
lab=Vref_comp}
N 2340 -1650 2400 -1650 {
lab=RISC_CLK}
N 2340 -1710 2400 -1710 {
lab=SAMPLE}
N 2340 -1690 2400 -1690 {
lab=Vrminus}
N 2340 -1670 2400 -1670 {
lab=Vrplus}
N 2340 -1750 2400 -1750 {
lab=WR}
N 2340 -1770 2400 -1770 {
lab=Vgnr}
N 2340 -1730 2400 -1730 {
lab=Vgpr}
N 3040 -1780 3100 -1780 {
lab=col4_sel}
N 3040 -1800 3100 -1800 {
lab=row0_sel}
N 3040 -1560 3100 -1560 {
lab=Vcplus}
N 3040 -1580 3100 -1580 {
lab=Vcminus}
N 3040 -1600 3100 -1600 {
lab=Vref}
N 3040 -1620 3100 -1620 {
lab=Vref_comp}
N 3040 -1640 3100 -1640 {
lab=RISC_CLK}
N 3040 -1700 3100 -1700 {
lab=SAMPLE}
N 3040 -1680 3100 -1680 {
lab=Vrminus}
N 3040 -1660 3100 -1660 {
lab=Vrplus}
N 3040 -1740 3100 -1740 {
lab=WR}
N 3040 -1760 3100 -1760 {
lab=Vgnr}
N 3040 -1720 3100 -1720 {
lab=Vgpr}
N 3750 -1780 3810 -1780 {
lab=col5_sel}
N 3750 -1800 3810 -1800 {
lab=row0_sel}
N 3750 -1560 3810 -1560 {
lab=Vcplus}
N 3750 -1580 3810 -1580 {
lab=Vcminus}
N 3750 -1600 3810 -1600 {
lab=Vref}
N 3750 -1620 3810 -1620 {
lab=Vref_comp}
N 3750 -1640 3810 -1640 {
lab=RISC_CLK}
N 3750 -1700 3810 -1700 {
lab=SAMPLE}
N 3750 -1680 3810 -1680 {
lab=Vrminus}
N 3750 -1660 3810 -1660 {
lab=Vrplus}
N 3750 -1740 3810 -1740 {
lab=WR}
N 3750 -1760 3810 -1760 {
lab=Vgnr}
N 3750 -1720 3810 -1720 {
lab=Vgpr}
N 190 -3340 250 -3340 {
lab=rA0}
N 600 -3340 660 -3340 {
lab=rB0}
N 600 -3360 660 -3360 {
lab=rB1}
N 600 -3380 660 -3380 {
lab=rB2}
N 600 -3400 660 -3400 {
lab=rB3}
N 600 -3420 660 -3420 {
lab=rB4}
N 600 -3440 660 -3440 {
lab=rB5}
N 600 -3460 660 -3460 {
lab=rB6}
N 600 -3480 660 -3480 {
lab=rB7}
N 600 -3500 660 -3500 {
lab=rB8}
N 600 -3520 660 -3520 {
lab=rB9}
N 600 -3540 660 -3540 {
lab=rB10}
N 600 -3560 660 -3560 {
lab=rB11}
N 600 -3580 660 -3580 {
lab=rB12}
N 600 -3600 660 -3600 {
lab=rB13}
N 600 -3620 660 -3620 {
lab=rB14}
N 600 -3640 660 -3640 {
lab=rB15}
N 190 -3000 250 -3000 {
lab=WL0}
N 190 -3020 250 -3020 {
lab=WL1}
N 190 -3040 250 -3040 {
lab=WL2}
N 190 -3060 250 -3060 {
lab=WL3}
N 190 -3080 250 -3080 {
lab=WL4}
N 190 -3100 250 -3100 {
lab=WL5}
N 190 -3120 250 -3120 {
lab=WL6}
N 190 -3140 250 -3140 {
lab=WL7}
N 190 -3160 250 -3160 {
lab=WL8}
N 190 -3180 250 -3180 {
lab=WL9}
N 190 -3200 250 -3200 {
lab=WL10}
N 190 -3220 250 -3220 {
lab=WL11}
N 190 -3240 250 -3240 {
lab=WL12}
N 190 -3260 250 -3260 {
lab=WL13}
N 190 -3280 250 -3280 {
lab=WL14}
N 190 -3300 250 -3300 {
lab=WL15}
N 190 -2660 250 -2660 {
lab=cA0}
N 190 -2680 250 -2680 {
lab=cA1}
N 190 -2700 250 -2700 {
lab=cA2}
N 190 -2720 250 -2720 {
lab=cA3}
N 190 -2740 250 -2740 {
lab=cA4}
N 190 -2760 250 -2760 {
lab=cA5}
N 190 -2780 250 -2780 {
lab=cA6}
N 190 -2800 250 -2800 {
lab=cA7}
N 190 -2820 250 -2820 {
lab=cA8}
N 190 -2840 250 -2840 {
lab=cA9}
N 190 -2860 250 -2860 {
lab=cA10}
N 190 -2880 250 -2880 {
lab=cA11}
N 190 -2900 250 -2900 {
lab=cA12}
N 190 -2920 250 -2920 {
lab=cA13}
N 190 -2940 250 -2940 {
lab=cA14}
N 190 -2960 250 -2960 {
lab=cA15}
N 190 -3920 250 -3920 {
lab=col0_sel}
N 190 -3940 250 -3940 {
lab=row1_sel}
N 190 -3880 250 -3880 {
lab=WR}
N 190 -3900 250 -3900 {
lab=Vgnr}
N 190 -3860 250 -3860 {
lab=Vgpr}
N 190 -3700 250 -3700 {
lab=Vcplus}
N 190 -3720 250 -3720 {
lab=Vcminus}
N 190 -3740 250 -3740 {
lab=Vref}
N 190 -3760 250 -3760 {
lab=Vref_comp}
N 190 -3780 250 -3780 {
lab=RISC_CLK}
N 550 -3880 610 -3880 {
lab=vssd1}
N 550 -3900 610 -3900 {
lab=vdda1}
N 550 -3920 610 -3920 {
lab=vccd1}
N 550 -3940 610 -3940 {
lab=latch_high0}
N 1970 -3930 2030 -3930 {
lab=latch_high2}
N 2700 -3880 2760 -3880 {
lab=vssd1}
N 2700 -3900 2760 -3900 {
lab=vdda1}
N 2700 -3920 2760 -3920 {
lab=vccd1}
N 2700 -3940 2760 -3940 {
lab=latch_high3}
N 3400 -3870 3460 -3870 {
lab=vssd1}
N 3400 -3890 3460 -3890 {
lab=vdda1}
N 3400 -3910 3460 -3910 {
lab=vccd1}
N 3400 -3930 3460 -3930 {
lab=latch_high4}
N 4110 -3870 4170 -3870 {
lab=vssd1}
N 4110 -3890 4170 -3890 {
lab=vdda1}
N 4110 -3910 4170 -3910 {
lab=vccd1}
N 4110 -3930 4170 -3930 {
lab=latch_high5}
N 130 -3000 190 -3000 {
lab=WL0}
N 130 -3020 190 -3020 {
lab=WL1}
N 130 -3040 190 -3040 {
lab=WL2}
N 130 -3060 190 -3060 {
lab=WL3}
N 130 -3080 190 -3080 {
lab=WL4}
N 130 -3100 190 -3100 {
lab=WL5}
N 130 -3120 190 -3120 {
lab=WL6}
N 130 -3140 190 -3140 {
lab=WL7}
N 130 -3160 190 -3160 {
lab=WL8}
N 130 -3180 190 -3180 {
lab=WL9}
N 130 -3200 190 -3200 {
lab=WL10}
N 130 -3220 190 -3220 {
lab=WL11}
N 130 -3240 190 -3240 {
lab=WL12}
N 130 -3260 190 -3260 {
lab=WL13}
N 130 -3280 190 -3280 {
lab=WL14}
N 130 -3300 190 -3300 {
lab=WL15}
N 70 -3000 130 -3000 {
lab=WL0}
N 70 -3020 130 -3020 {
lab=WL1}
N 70 -3040 130 -3040 {
lab=WL2}
N 70 -3060 130 -3060 {
lab=WL3}
N 70 -3080 130 -3080 {
lab=WL4}
N 70 -3100 130 -3100 {
lab=WL5}
N 70 -3120 130 -3120 {
lab=WL6}
N 70 -3140 130 -3140 {
lab=WL7}
N 70 -3160 130 -3160 {
lab=WL8}
N 70 -3180 130 -3180 {
lab=WL9}
N 70 -3200 130 -3200 {
lab=WL10}
N 70 -3220 130 -3220 {
lab=WL11}
N 70 -3240 130 -3240 {
lab=WL12}
N 70 -3260 130 -3260 {
lab=WL13}
N 70 -3280 130 -3280 {
lab=WL14}
N 70 -3300 130 -3300 {
lab=WL15}
N 60 -3290 60 -2990 {bus=true
lab=WL[0..15]}
N 60 -2990 60 -2960 {bus=true
lab=WL[0..15]}
N 910 -3000 970 -3000 {
lab=WL0}
N 910 -3020 970 -3020 {
lab=WL1}
N 910 -3040 970 -3040 {
lab=WL2}
N 910 -3060 970 -3060 {
lab=WL3}
N 910 -3080 970 -3080 {
lab=WL4}
N 910 -3100 970 -3100 {
lab=WL5}
N 910 -3120 970 -3120 {
lab=WL6}
N 910 -3140 970 -3140 {
lab=WL7}
N 910 -3160 970 -3160 {
lab=WL8}
N 910 -3180 970 -3180 {
lab=WL9}
N 910 -3200 970 -3200 {
lab=WL10}
N 910 -3220 970 -3220 {
lab=WL11}
N 910 -3240 970 -3240 {
lab=WL12}
N 910 -3260 970 -3260 {
lab=WL13}
N 910 -3280 970 -3280 {
lab=WL14}
N 910 -3300 970 -3300 {
lab=WL15}
N 850 -3000 910 -3000 {
lab=WL0}
N 850 -3020 910 -3020 {
lab=WL1}
N 850 -3040 910 -3040 {
lab=WL2}
N 850 -3060 910 -3060 {
lab=WL3}
N 850 -3080 910 -3080 {
lab=WL4}
N 850 -3100 910 -3100 {
lab=WL5}
N 850 -3120 910 -3120 {
lab=WL6}
N 850 -3140 910 -3140 {
lab=WL7}
N 850 -3160 910 -3160 {
lab=WL8}
N 850 -3180 910 -3180 {
lab=WL9}
N 850 -3200 910 -3200 {
lab=WL10}
N 850 -3220 910 -3220 {
lab=WL11}
N 850 -3240 910 -3240 {
lab=WL12}
N 850 -3260 910 -3260 {
lab=WL13}
N 850 -3280 910 -3280 {
lab=WL14}
N 850 -3300 910 -3300 {
lab=WL15}
N 790 -3000 850 -3000 {
lab=WL0}
N 790 -3020 850 -3020 {
lab=WL1}
N 790 -3040 850 -3040 {
lab=WL2}
N 790 -3060 850 -3060 {
lab=WL3}
N 790 -3080 850 -3080 {
lab=WL4}
N 790 -3100 850 -3100 {
lab=WL5}
N 790 -3120 850 -3120 {
lab=WL6}
N 790 -3140 850 -3140 {
lab=WL7}
N 790 -3160 850 -3160 {
lab=WL8}
N 790 -3180 850 -3180 {
lab=WL9}
N 790 -3200 850 -3200 {
lab=WL10}
N 790 -3220 850 -3220 {
lab=WL11}
N 790 -3240 850 -3240 {
lab=WL12}
N 790 -3260 850 -3260 {
lab=WL13}
N 790 -3280 850 -3280 {
lab=WL14}
N 790 -3300 850 -3300 {
lab=WL15}
N 780 -3290 780 -2990 {bus=true
lab=WL[0..15]}
N 780 -2990 780 -2960 {bus=true
lab=WL[0..15]}
N 1610 -2990 1670 -2990 {
lab=WL0}
N 1610 -3010 1670 -3010 {
lab=WL1}
N 1610 -3030 1670 -3030 {
lab=WL2}
N 1610 -3050 1670 -3050 {
lab=WL3}
N 1610 -3070 1670 -3070 {
lab=WL4}
N 1610 -3090 1670 -3090 {
lab=WL5}
N 1610 -3110 1670 -3110 {
lab=WL6}
N 1610 -3130 1670 -3130 {
lab=WL7}
N 1610 -3150 1670 -3150 {
lab=WL8}
N 1610 -3170 1670 -3170 {
lab=WL9}
N 1610 -3190 1670 -3190 {
lab=WL10}
N 1610 -3210 1670 -3210 {
lab=WL11}
N 1610 -3230 1670 -3230 {
lab=WL12}
N 1610 -3250 1670 -3250 {
lab=WL13}
N 1610 -3270 1670 -3270 {
lab=WL14}
N 1610 -3290 1670 -3290 {
lab=WL15}
N 1550 -2990 1610 -2990 {
lab=WL0}
N 1550 -3010 1610 -3010 {
lab=WL1}
N 1550 -3030 1610 -3030 {
lab=WL2}
N 1550 -3050 1610 -3050 {
lab=WL3}
N 1550 -3070 1610 -3070 {
lab=WL4}
N 1550 -3090 1610 -3090 {
lab=WL5}
N 1550 -3110 1610 -3110 {
lab=WL6}
N 1550 -3130 1610 -3130 {
lab=WL7}
N 1550 -3150 1610 -3150 {
lab=WL8}
N 1550 -3170 1610 -3170 {
lab=WL9}
N 1550 -3190 1610 -3190 {
lab=WL10}
N 1550 -3210 1610 -3210 {
lab=WL11}
N 1550 -3230 1610 -3230 {
lab=WL12}
N 1550 -3250 1610 -3250 {
lab=WL13}
N 1550 -3270 1610 -3270 {
lab=WL14}
N 1550 -3290 1610 -3290 {
lab=WL15}
N 1490 -2990 1550 -2990 {
lab=WL0}
N 1490 -3010 1550 -3010 {
lab=WL1}
N 1490 -3030 1550 -3030 {
lab=WL2}
N 1490 -3050 1550 -3050 {
lab=WL3}
N 1490 -3070 1550 -3070 {
lab=WL4}
N 1490 -3090 1550 -3090 {
lab=WL5}
N 1490 -3110 1550 -3110 {
lab=WL6}
N 1490 -3130 1550 -3130 {
lab=WL7}
N 1490 -3150 1550 -3150 {
lab=WL8}
N 1490 -3170 1550 -3170 {
lab=WL9}
N 1490 -3190 1550 -3190 {
lab=WL10}
N 1490 -3210 1550 -3210 {
lab=WL11}
N 1490 -3230 1550 -3230 {
lab=WL12}
N 1490 -3250 1550 -3250 {
lab=WL13}
N 1490 -3270 1550 -3270 {
lab=WL14}
N 1490 -3290 1550 -3290 {
lab=WL15}
N 1480 -3280 1480 -2980 {bus=true
lab=WL[0..15]}
N 1480 -2980 1480 -2950 {bus=true
lab=WL[0..15]}
N 2340 -3000 2400 -3000 {
lab=WL0}
N 2340 -3020 2400 -3020 {
lab=WL1}
N 2340 -3040 2400 -3040 {
lab=WL2}
N 2340 -3060 2400 -3060 {
lab=WL3}
N 2340 -3080 2400 -3080 {
lab=WL4}
N 2340 -3100 2400 -3100 {
lab=WL5}
N 2340 -3120 2400 -3120 {
lab=WL6}
N 2340 -3140 2400 -3140 {
lab=WL7}
N 2340 -3160 2400 -3160 {
lab=WL8}
N 2340 -3180 2400 -3180 {
lab=WL9}
N 2340 -3200 2400 -3200 {
lab=WL10}
N 2340 -3220 2400 -3220 {
lab=WL11}
N 2340 -3240 2400 -3240 {
lab=WL12}
N 2340 -3260 2400 -3260 {
lab=WL13}
N 2340 -3280 2400 -3280 {
lab=WL14}
N 2340 -3300 2400 -3300 {
lab=WL15}
N 2280 -3000 2340 -3000 {
lab=WL0}
N 2280 -3020 2340 -3020 {
lab=WL1}
N 2280 -3040 2340 -3040 {
lab=WL2}
N 2280 -3060 2340 -3060 {
lab=WL3}
N 2280 -3080 2340 -3080 {
lab=WL4}
N 2280 -3100 2340 -3100 {
lab=WL5}
N 2280 -3120 2340 -3120 {
lab=WL6}
N 2280 -3140 2340 -3140 {
lab=WL7}
N 2280 -3160 2340 -3160 {
lab=WL8}
N 2280 -3180 2340 -3180 {
lab=WL9}
N 2280 -3200 2340 -3200 {
lab=WL10}
N 2280 -3220 2340 -3220 {
lab=WL11}
N 2280 -3240 2340 -3240 {
lab=WL12}
N 2280 -3260 2340 -3260 {
lab=WL13}
N 2280 -3280 2340 -3280 {
lab=WL14}
N 2280 -3300 2340 -3300 {
lab=WL15}
N 2220 -3000 2280 -3000 {
lab=WL0}
N 2220 -3020 2280 -3020 {
lab=WL1}
N 2220 -3040 2280 -3040 {
lab=WL2}
N 2220 -3060 2280 -3060 {
lab=WL3}
N 2220 -3080 2280 -3080 {
lab=WL4}
N 2220 -3100 2280 -3100 {
lab=WL5}
N 2220 -3120 2280 -3120 {
lab=WL6}
N 2220 -3140 2280 -3140 {
lab=WL7}
N 2220 -3160 2280 -3160 {
lab=WL8}
N 2220 -3180 2280 -3180 {
lab=WL9}
N 2220 -3200 2280 -3200 {
lab=WL10}
N 2220 -3220 2280 -3220 {
lab=WL11}
N 2220 -3240 2280 -3240 {
lab=WL12}
N 2220 -3260 2280 -3260 {
lab=WL13}
N 2220 -3280 2280 -3280 {
lab=WL14}
N 2220 -3300 2280 -3300 {
lab=WL15}
N 2210 -3290 2210 -2990 {bus=true
lab=WL[0..15]}
N 2210 -2990 2210 -2960 {bus=true
lab=WL[0..15]}
N 3040 -2990 3100 -2990 {
lab=WL0}
N 3040 -3010 3100 -3010 {
lab=WL1}
N 3040 -3030 3100 -3030 {
lab=WL2}
N 3040 -3050 3100 -3050 {
lab=WL3}
N 3040 -3070 3100 -3070 {
lab=WL4}
N 3040 -3090 3100 -3090 {
lab=WL5}
N 3040 -3110 3100 -3110 {
lab=WL6}
N 3040 -3130 3100 -3130 {
lab=WL7}
N 3040 -3150 3100 -3150 {
lab=WL8}
N 3040 -3170 3100 -3170 {
lab=WL9}
N 3040 -3190 3100 -3190 {
lab=WL10}
N 3040 -3210 3100 -3210 {
lab=WL11}
N 3040 -3230 3100 -3230 {
lab=WL12}
N 3040 -3250 3100 -3250 {
lab=WL13}
N 3040 -3270 3100 -3270 {
lab=WL14}
N 3040 -3290 3100 -3290 {
lab=WL15}
N 2980 -2990 3040 -2990 {
lab=WL0}
N 2980 -3010 3040 -3010 {
lab=WL1}
N 2980 -3030 3040 -3030 {
lab=WL2}
N 2980 -3050 3040 -3050 {
lab=WL3}
N 2980 -3070 3040 -3070 {
lab=WL4}
N 2980 -3090 3040 -3090 {
lab=WL5}
N 2980 -3110 3040 -3110 {
lab=WL6}
N 2980 -3130 3040 -3130 {
lab=WL7}
N 2980 -3150 3040 -3150 {
lab=WL8}
N 2980 -3170 3040 -3170 {
lab=WL9}
N 2980 -3190 3040 -3190 {
lab=WL10}
N 2980 -3210 3040 -3210 {
lab=WL11}
N 2980 -3230 3040 -3230 {
lab=WL12}
N 2980 -3250 3040 -3250 {
lab=WL13}
N 2980 -3270 3040 -3270 {
lab=WL14}
N 2980 -3290 3040 -3290 {
lab=WL15}
N 2920 -2990 2980 -2990 {
lab=WL0}
N 2920 -3010 2980 -3010 {
lab=WL1}
N 2920 -3030 2980 -3030 {
lab=WL2}
N 2920 -3050 2980 -3050 {
lab=WL3}
N 2920 -3070 2980 -3070 {
lab=WL4}
N 2920 -3090 2980 -3090 {
lab=WL5}
N 2920 -3110 2980 -3110 {
lab=WL6}
N 2920 -3130 2980 -3130 {
lab=WL7}
N 2920 -3150 2980 -3150 {
lab=WL8}
N 2920 -3170 2980 -3170 {
lab=WL9}
N 2920 -3190 2980 -3190 {
lab=WL10}
N 2920 -3210 2980 -3210 {
lab=WL11}
N 2920 -3230 2980 -3230 {
lab=WL12}
N 2920 -3250 2980 -3250 {
lab=WL13}
N 2920 -3270 2980 -3270 {
lab=WL14}
N 2920 -3290 2980 -3290 {
lab=WL15}
N 2910 -3280 2910 -2980 {bus=true
lab=WL[0..15]}
N 2910 -2980 2910 -2950 {bus=true
lab=WL[0..15]}
N 3750 -2990 3810 -2990 {
lab=WL0}
N 3750 -3010 3810 -3010 {
lab=WL1}
N 3750 -3030 3810 -3030 {
lab=WL2}
N 3750 -3050 3810 -3050 {
lab=WL3}
N 3750 -3070 3810 -3070 {
lab=WL4}
N 3750 -3090 3810 -3090 {
lab=WL5}
N 3750 -3110 3810 -3110 {
lab=WL6}
N 3750 -3130 3810 -3130 {
lab=WL7}
N 3750 -3150 3810 -3150 {
lab=WL8}
N 3750 -3170 3810 -3170 {
lab=WL9}
N 3750 -3190 3810 -3190 {
lab=WL10}
N 3750 -3210 3810 -3210 {
lab=WL11}
N 3750 -3230 3810 -3230 {
lab=WL12}
N 3750 -3250 3810 -3250 {
lab=WL13}
N 3750 -3270 3810 -3270 {
lab=WL14}
N 3750 -3290 3810 -3290 {
lab=WL15}
N 3690 -2990 3750 -2990 {
lab=WL0}
N 3690 -3010 3750 -3010 {
lab=WL1}
N 3690 -3030 3750 -3030 {
lab=WL2}
N 3690 -3050 3750 -3050 {
lab=WL3}
N 3690 -3070 3750 -3070 {
lab=WL4}
N 3690 -3090 3750 -3090 {
lab=WL5}
N 3690 -3110 3750 -3110 {
lab=WL6}
N 3690 -3130 3750 -3130 {
lab=WL7}
N 3690 -3150 3750 -3150 {
lab=WL8}
N 3690 -3170 3750 -3170 {
lab=WL9}
N 3690 -3190 3750 -3190 {
lab=WL10}
N 3690 -3210 3750 -3210 {
lab=WL11}
N 3690 -3230 3750 -3230 {
lab=WL12}
N 3690 -3250 3750 -3250 {
lab=WL13}
N 3690 -3270 3750 -3270 {
lab=WL14}
N 3690 -3290 3750 -3290 {
lab=WL15}
N 3630 -2990 3690 -2990 {
lab=WL0}
N 3630 -3010 3690 -3010 {
lab=WL1}
N 3630 -3030 3690 -3030 {
lab=WL2}
N 3630 -3050 3690 -3050 {
lab=WL3}
N 3630 -3070 3690 -3070 {
lab=WL4}
N 3630 -3090 3690 -3090 {
lab=WL5}
N 3630 -3110 3690 -3110 {
lab=WL6}
N 3630 -3130 3690 -3130 {
lab=WL7}
N 3630 -3150 3690 -3150 {
lab=WL8}
N 3630 -3170 3690 -3170 {
lab=WL9}
N 3630 -3190 3690 -3190 {
lab=WL10}
N 3630 -3210 3690 -3210 {
lab=WL11}
N 3630 -3230 3690 -3230 {
lab=WL12}
N 3630 -3250 3690 -3250 {
lab=WL13}
N 3630 -3270 3690 -3270 {
lab=WL14}
N 3630 -3290 3690 -3290 {
lab=WL15}
N 3620 -3280 3620 -2980 {bus=true
lab=WL[0..15]}
N 3620 -2980 3620 -2950 {bus=true
lab=WL[0..15]}
N 40 -3340 190 -3340 {
lab=rA0}
N 40 -3380 190 -3380 {
lab=rA2}
N 40 -3400 190 -3400 {
lab=rA3}
N 40 -3420 190 -3420 {
lab=rA4}
N 40 -3440 190 -3440 {
lab=rA5}
N 40 -3460 190 -3460 {
lab=rA6}
N 40 -3480 190 -3480 {
lab=rA7}
N 40 -3500 190 -3500 {
lab=rA8}
N 40 -3540 190 -3540 {
lab=rA10}
N 40 -3520 190 -3520 {
lab=rA9}
N 40 -3560 190 -3560 {
lab=rA11}
N 40 -3580 190 -3580 {
lab=rA12}
N 40 -3600 190 -3600 {
lab=rA13}
N 40 -3620 190 -3620 {
lab=rA14}
N 40 -3640 190 -3640 {
lab=rA15}
N 190 -3840 250 -3840 {
lab=SAMPLE}
N 190 -3820 250 -3820 {
lab=Vrminus}
N 190 -3800 250 -3800 {
lab=Vrplus}
N 40 -3360 190 -3360 {
lab=rA1}
N 190 -3360 250 -3360 {
lab=rA1}
N 190 -3380 250 -3380 {
lab=rA2}
N 190 -3400 250 -3400 {
lab=rA3}
N 190 -3420 250 -3420 {
lab=rA4}
N 190 -3440 250 -3440 {
lab=rA5}
N 190 -3460 250 -3460 {
lab=rA6}
N 190 -3480 250 -3480 {
lab=rA7}
N 190 -3500 250 -3500 {
lab=rA8}
N 190 -3520 250 -3520 {
lab=rA9}
N 190 -3540 250 -3540 {
lab=rA10}
N 190 -3560 250 -3560 {
lab=rA11}
N 190 -3580 250 -3580 {
lab=rA12}
N 190 -3600 250 -3600 {
lab=rA13}
N 190 -3620 250 -3620 {
lab=rA14}
N 190 -3640 250 -3640 {
lab=rA15}
N 30 -3630 30 -3290 {
lab=rA[0..15]
bus=true}
N 550 -3340 600 -3340 {
lab=rB0}
N 550 -3360 600 -3360 {
lab=rB1}
N 670 -3350 670 -3290 {
lab=rB[0..15]
bus=true}
N 550 -3380 600 -3380 {
lab=rB2}
N 550 -3400 600 -3400 {
lab=rB3}
N 550 -3420 600 -3420 {
lab=rB4}
N 550 -3440 600 -3440 {
lab=rB5}
N 550 -3460 600 -3460 {
lab=rB6}
N 550 -3480 600 -3480 {
lab=rB7}
N 550 -3500 600 -3500 {
lab=rB8}
N 550 -3520 600 -3520 {
lab=rB9}
N 550 -3540 600 -3540 {
lab=rB10}
N 550 -3560 600 -3560 {
lab=rB11}
N 550 -3580 600 -3580 {
lab=rB12}
N 550 -3600 600 -3600 {
lab=rB13}
N 550 -3620 600 -3620 {
lab=rB14}
N 550 -3640 600 -3640 {
lab=rB15}
N 670 -3630 670 -3350 {
lab=rB[0..15]
bus=true}
N 180 -2950 180 -2650 {bus=true
lab=cA[0..15]}
N 180 -2650 180 -2620 {bus=true
lab=cA[0..15]}
N 550 -2660 610 -2660 {
lab=cB0}
N 550 -2680 610 -2680 {
lab=cB1}
N 550 -2700 610 -2700 {
lab=cB2}
N 550 -2720 610 -2720 {
lab=cB3}
N 550 -2740 610 -2740 {
lab=cB4}
N 550 -2760 610 -2760 {
lab=cB5}
N 550 -2780 610 -2780 {
lab=cB6}
N 550 -2800 610 -2800 {
lab=cB7}
N 550 -2820 610 -2820 {
lab=cB8}
N 550 -2840 610 -2840 {
lab=cB9}
N 550 -2860 610 -2860 {
lab=cB10}
N 550 -2880 610 -2880 {
lab=cB11}
N 550 -2900 610 -2900 {
lab=cB12}
N 550 -2920 610 -2920 {
lab=cB13}
N 550 -2940 610 -2940 {
lab=cB14}
N 550 -2960 610 -2960 {
lab=cB15}
N 620 -2950 620 -2650 {bus=true
lab=cB[0..15]}
N 620 -2650 620 -2620 {bus=true
lab=cB[0..15]}
N 910 -3340 970 -3340 {
lab=rA0}
N 1320 -3340 1380 -3340 {
lab=rB0}
N 1320 -3360 1380 -3360 {
lab=rB1}
N 1320 -3380 1380 -3380 {
lab=rB2}
N 1320 -3400 1380 -3400 {
lab=rB3}
N 1320 -3420 1380 -3420 {
lab=rB4}
N 1320 -3440 1380 -3440 {
lab=rB5}
N 1320 -3460 1380 -3460 {
lab=rB6}
N 1320 -3480 1380 -3480 {
lab=rB7}
N 1320 -3500 1380 -3500 {
lab=rB8}
N 1320 -3520 1380 -3520 {
lab=rB9}
N 1320 -3540 1380 -3540 {
lab=rB10}
N 1320 -3560 1380 -3560 {
lab=rB11}
N 1320 -3580 1380 -3580 {
lab=rB12}
N 1320 -3600 1380 -3600 {
lab=rB13}
N 1320 -3620 1380 -3620 {
lab=rB14}
N 1320 -3640 1380 -3640 {
lab=rB15}
N 910 -3920 970 -3920 {
lab=col1_sel}
N 910 -3940 970 -3940 {
lab=row1_sel}
N 910 -3700 970 -3700 {
lab=Vcplus}
N 910 -3720 970 -3720 {
lab=Vcminus}
N 910 -3740 970 -3740 {
lab=Vref}
N 910 -3760 970 -3760 {
lab=Vref_comp}
N 910 -3780 970 -3780 {
lab=RISC_CLK}
N 1270 -3880 1330 -3880 {
lab=vssd1}
N 1270 -3900 1330 -3900 {
lab=vdda1}
N 1270 -3920 1330 -3920 {
lab=vccd1}
N 1270 -3940 1330 -3940 {
lab=latch_high1}
N 760 -3340 910 -3340 {
lab=rA0}
N 760 -3380 910 -3380 {
lab=rA2}
N 760 -3400 910 -3400 {
lab=rA3}
N 760 -3420 910 -3420 {
lab=rA4}
N 760 -3440 910 -3440 {
lab=rA5}
N 760 -3460 910 -3460 {
lab=rA6}
N 760 -3480 910 -3480 {
lab=rA7}
N 760 -3500 910 -3500 {
lab=rA8}
N 760 -3540 910 -3540 {
lab=rA10}
N 760 -3520 910 -3520 {
lab=rA9}
N 760 -3560 910 -3560 {
lab=rA11}
N 760 -3580 910 -3580 {
lab=rA12}
N 760 -3600 910 -3600 {
lab=rA13}
N 760 -3620 910 -3620 {
lab=rA14}
N 760 -3640 910 -3640 {
lab=rA15}
N 910 -3840 970 -3840 {
lab=SAMPLE}
N 910 -3820 970 -3820 {
lab=Vrminus}
N 910 -3800 970 -3800 {
lab=Vrplus}
N 760 -3360 910 -3360 {
lab=rA1}
N 910 -3360 970 -3360 {
lab=rA1}
N 910 -3380 970 -3380 {
lab=rA2}
N 910 -3400 970 -3400 {
lab=rA3}
N 910 -3420 970 -3420 {
lab=rA4}
N 910 -3440 970 -3440 {
lab=rA5}
N 910 -3460 970 -3460 {
lab=rA6}
N 910 -3480 970 -3480 {
lab=rA7}
N 910 -3500 970 -3500 {
lab=rA8}
N 910 -3520 970 -3520 {
lab=rA9}
N 910 -3540 970 -3540 {
lab=rA10}
N 910 -3560 970 -3560 {
lab=rA11}
N 910 -3580 970 -3580 {
lab=rA12}
N 910 -3600 970 -3600 {
lab=rA13}
N 910 -3620 970 -3620 {
lab=rA14}
N 910 -3640 970 -3640 {
lab=rA15}
N 750 -3630 750 -3290 {
lab=rA[0..15]
bus=true}
N 1270 -3340 1320 -3340 {
lab=rB0}
N 1270 -3360 1320 -3360 {
lab=rB1}
N 1390 -3350 1390 -3290 {
lab=rB[0..15]
bus=true}
N 1270 -3380 1320 -3380 {
lab=rB2}
N 1270 -3400 1320 -3400 {
lab=rB3}
N 1270 -3420 1320 -3420 {
lab=rB4}
N 1270 -3440 1320 -3440 {
lab=rB5}
N 1270 -3460 1320 -3460 {
lab=rB6}
N 1270 -3480 1320 -3480 {
lab=rB7}
N 1270 -3500 1320 -3500 {
lab=rB8}
N 1270 -3520 1320 -3520 {
lab=rB9}
N 1270 -3540 1320 -3540 {
lab=rB10}
N 1270 -3560 1320 -3560 {
lab=rB11}
N 1270 -3580 1320 -3580 {
lab=rB12}
N 1270 -3600 1320 -3600 {
lab=rB13}
N 1270 -3620 1320 -3620 {
lab=rB14}
N 1270 -3640 1320 -3640 {
lab=rB15}
N 1390 -3630 1390 -3350 {
lab=rB[0..15]
bus=true}
N 910 -3880 970 -3880 {
lab=WR}
N 910 -3900 970 -3900 {
lab=Vgnr}
N 910 -3860 970 -3860 {
lab=Vgpr}
N 1610 -3910 1670 -3910 {
lab=col2_sel}
N 1610 -3930 1670 -3930 {
lab=row1_sel}
N 1610 -3690 1670 -3690 {
lab=Vcplus}
N 1610 -3710 1670 -3710 {
lab=Vcminus}
N 1610 -3730 1670 -3730 {
lab=Vref}
N 1610 -3750 1670 -3750 {
lab=Vref_comp}
N 1610 -3770 1670 -3770 {
lab=RISC_CLK}
N 1610 -3830 1670 -3830 {
lab=SAMPLE}
N 1610 -3810 1670 -3810 {
lab=Vrminus}
N 1610 -3790 1670 -3790 {
lab=Vrplus}
N 1610 -3870 1670 -3870 {
lab=WR}
N 1610 -3890 1670 -3890 {
lab=Vgnr}
N 1610 -3850 1670 -3850 {
lab=Vgpr}
N 1970 -3870 2030 -3870 {
lab=vssd1}
N 1970 -3890 2030 -3890 {
lab=vdda1}
N 1970 -3910 2030 -3910 {
lab=vccd1}
N 1610 -3330 1670 -3330 {
lab=rA0}
N 2020 -3330 2080 -3330 {
lab=rB0}
N 2020 -3350 2080 -3350 {
lab=rB1}
N 2020 -3370 2080 -3370 {
lab=rB2}
N 2020 -3390 2080 -3390 {
lab=rB3}
N 2020 -3410 2080 -3410 {
lab=rB4}
N 2020 -3430 2080 -3430 {
lab=rB5}
N 2020 -3450 2080 -3450 {
lab=rB6}
N 2020 -3470 2080 -3470 {
lab=rB7}
N 2020 -3490 2080 -3490 {
lab=rB8}
N 2020 -3510 2080 -3510 {
lab=rB9}
N 2020 -3530 2080 -3530 {
lab=rB10}
N 2020 -3550 2080 -3550 {
lab=rB11}
N 2020 -3570 2080 -3570 {
lab=rB12}
N 2020 -3590 2080 -3590 {
lab=rB13}
N 2020 -3610 2080 -3610 {
lab=rB14}
N 2020 -3630 2080 -3630 {
lab=rB15}
N 1460 -3330 1610 -3330 {
lab=rA0}
N 1460 -3370 1610 -3370 {
lab=rA2}
N 1460 -3390 1610 -3390 {
lab=rA3}
N 1460 -3410 1610 -3410 {
lab=rA4}
N 1460 -3430 1610 -3430 {
lab=rA5}
N 1460 -3450 1610 -3450 {
lab=rA6}
N 1460 -3470 1610 -3470 {
lab=rA7}
N 1460 -3490 1610 -3490 {
lab=rA8}
N 1460 -3530 1610 -3530 {
lab=rA10}
N 1460 -3510 1610 -3510 {
lab=rA9}
N 1460 -3550 1610 -3550 {
lab=rA11}
N 1460 -3570 1610 -3570 {
lab=rA12}
N 1460 -3590 1610 -3590 {
lab=rA13}
N 1460 -3610 1610 -3610 {
lab=rA14}
N 1460 -3630 1610 -3630 {
lab=rA15}
N 1460 -3350 1610 -3350 {
lab=rA1}
N 1610 -3350 1670 -3350 {
lab=rA1}
N 1610 -3370 1670 -3370 {
lab=rA2}
N 1610 -3390 1670 -3390 {
lab=rA3}
N 1610 -3410 1670 -3410 {
lab=rA4}
N 1610 -3430 1670 -3430 {
lab=rA5}
N 1610 -3450 1670 -3450 {
lab=rA6}
N 1610 -3470 1670 -3470 {
lab=rA7}
N 1610 -3490 1670 -3490 {
lab=rA8}
N 1610 -3510 1670 -3510 {
lab=rA9}
N 1610 -3530 1670 -3530 {
lab=rA10}
N 1610 -3550 1670 -3550 {
lab=rA11}
N 1610 -3570 1670 -3570 {
lab=rA12}
N 1610 -3590 1670 -3590 {
lab=rA13}
N 1610 -3610 1670 -3610 {
lab=rA14}
N 1610 -3630 1670 -3630 {
lab=rA15}
N 1450 -3620 1450 -3280 {
lab=rA[0..15]
bus=true}
N 1970 -3330 2020 -3330 {
lab=rB0}
N 1970 -3350 2020 -3350 {
lab=rB1}
N 2090 -3340 2090 -3280 {
lab=rB[0..15]
bus=true}
N 1970 -3370 2020 -3370 {
lab=rB2}
N 1970 -3390 2020 -3390 {
lab=rB3}
N 1970 -3410 2020 -3410 {
lab=rB4}
N 1970 -3430 2020 -3430 {
lab=rB5}
N 1970 -3450 2020 -3450 {
lab=rB6}
N 1970 -3470 2020 -3470 {
lab=rB7}
N 1970 -3490 2020 -3490 {
lab=rB8}
N 1970 -3510 2020 -3510 {
lab=rB9}
N 1970 -3530 2020 -3530 {
lab=rB10}
N 1970 -3550 2020 -3550 {
lab=rB11}
N 1970 -3570 2020 -3570 {
lab=rB12}
N 1970 -3590 2020 -3590 {
lab=rB13}
N 1970 -3610 2020 -3610 {
lab=rB14}
N 1970 -3630 2020 -3630 {
lab=rB15}
N 2090 -3620 2090 -3340 {
lab=rB[0..15]
bus=true}
N 910 -2660 970 -2660 {
lab=cA0}
N 910 -2680 970 -2680 {
lab=cA1}
N 910 -2700 970 -2700 {
lab=cA2}
N 910 -2720 970 -2720 {
lab=cA3}
N 910 -2740 970 -2740 {
lab=cA4}
N 910 -2760 970 -2760 {
lab=cA5}
N 910 -2780 970 -2780 {
lab=cA6}
N 910 -2800 970 -2800 {
lab=cA7}
N 910 -2820 970 -2820 {
lab=cA8}
N 910 -2840 970 -2840 {
lab=cA9}
N 910 -2860 970 -2860 {
lab=cA10}
N 910 -2880 970 -2880 {
lab=cA11}
N 910 -2900 970 -2900 {
lab=cA12}
N 910 -2920 970 -2920 {
lab=cA13}
N 910 -2940 970 -2940 {
lab=cA14}
N 910 -2960 970 -2960 {
lab=cA15}
N 900 -2950 900 -2650 {bus=true
lab=cA[0..15]}
N 900 -2650 900 -2620 {bus=true
lab=cA[0..15]}
N 1270 -2660 1330 -2660 {
lab=cB0}
N 1270 -2680 1330 -2680 {
lab=cB1}
N 1270 -2700 1330 -2700 {
lab=cB2}
N 1270 -2720 1330 -2720 {
lab=cB3}
N 1270 -2740 1330 -2740 {
lab=cB4}
N 1270 -2760 1330 -2760 {
lab=cB5}
N 1270 -2780 1330 -2780 {
lab=cB6}
N 1270 -2800 1330 -2800 {
lab=cB7}
N 1270 -2820 1330 -2820 {
lab=cB8}
N 1270 -2840 1330 -2840 {
lab=cB9}
N 1270 -2860 1330 -2860 {
lab=cB10}
N 1270 -2880 1330 -2880 {
lab=cB11}
N 1270 -2900 1330 -2900 {
lab=cB12}
N 1270 -2920 1330 -2920 {
lab=cB13}
N 1270 -2940 1330 -2940 {
lab=cB14}
N 1270 -2960 1330 -2960 {
lab=cB15}
N 1340 -2950 1340 -2650 {bus=true
lab=cB[0..15]}
N 1340 -2650 1340 -2620 {bus=true
lab=cB[0..15]}
N 1610 -2650 1670 -2650 {
lab=cA0}
N 1610 -2670 1670 -2670 {
lab=cA1}
N 1610 -2690 1670 -2690 {
lab=cA2}
N 1610 -2710 1670 -2710 {
lab=cA3}
N 1610 -2730 1670 -2730 {
lab=cA4}
N 1610 -2750 1670 -2750 {
lab=cA5}
N 1610 -2770 1670 -2770 {
lab=cA6}
N 1610 -2790 1670 -2790 {
lab=cA7}
N 1610 -2810 1670 -2810 {
lab=cA8}
N 1610 -2830 1670 -2830 {
lab=cA9}
N 1610 -2850 1670 -2850 {
lab=cA10}
N 1610 -2870 1670 -2870 {
lab=cA11}
N 1610 -2890 1670 -2890 {
lab=cA12}
N 1610 -2910 1670 -2910 {
lab=cA13}
N 1610 -2930 1670 -2930 {
lab=cA14}
N 1610 -2950 1670 -2950 {
lab=cA15}
N 1600 -2940 1600 -2640 {bus=true
lab=cA[0..15]}
N 1600 -2640 1600 -2610 {bus=true
lab=cA[0..15]}
N 1970 -2650 2030 -2650 {
lab=cB0}
N 1970 -2670 2030 -2670 {
lab=cB1}
N 1970 -2690 2030 -2690 {
lab=cB2}
N 1970 -2710 2030 -2710 {
lab=cB3}
N 1970 -2730 2030 -2730 {
lab=cB4}
N 1970 -2750 2030 -2750 {
lab=cB5}
N 1970 -2770 2030 -2770 {
lab=cB6}
N 1970 -2790 2030 -2790 {
lab=cB7}
N 1970 -2810 2030 -2810 {
lab=cB8}
N 1970 -2830 2030 -2830 {
lab=cB9}
N 1970 -2850 2030 -2850 {
lab=cB10}
N 1970 -2870 2030 -2870 {
lab=cB11}
N 1970 -2890 2030 -2890 {
lab=cB12}
N 1970 -2910 2030 -2910 {
lab=cB13}
N 1970 -2930 2030 -2930 {
lab=cB14}
N 1970 -2950 2030 -2950 {
lab=cB15}
N 2040 -2940 2040 -2640 {bus=true
lab=cB[0..15]}
N 2040 -2640 2040 -2610 {bus=true
lab=cB[0..15]}
N 2340 -3340 2400 -3340 {
lab=rA0}
N 2750 -3340 2810 -3340 {
lab=rB0}
N 2750 -3360 2810 -3360 {
lab=rB1}
N 2750 -3380 2810 -3380 {
lab=rB2}
N 2750 -3400 2810 -3400 {
lab=rB3}
N 2750 -3420 2810 -3420 {
lab=rB4}
N 2750 -3440 2810 -3440 {
lab=rB5}
N 2750 -3460 2810 -3460 {
lab=rB6}
N 2750 -3480 2810 -3480 {
lab=rB7}
N 2750 -3500 2810 -3500 {
lab=rB8}
N 2750 -3520 2810 -3520 {
lab=rB9}
N 2750 -3540 2810 -3540 {
lab=rB10}
N 2750 -3560 2810 -3560 {
lab=rB11}
N 2750 -3580 2810 -3580 {
lab=rB12}
N 2750 -3600 2810 -3600 {
lab=rB13}
N 2750 -3620 2810 -3620 {
lab=rB14}
N 2750 -3640 2810 -3640 {
lab=rB15}
N 2190 -3340 2340 -3340 {
lab=rA0}
N 2190 -3380 2340 -3380 {
lab=rA2}
N 2190 -3400 2340 -3400 {
lab=rA3}
N 2190 -3420 2340 -3420 {
lab=rA4}
N 2190 -3440 2340 -3440 {
lab=rA5}
N 2190 -3460 2340 -3460 {
lab=rA6}
N 2190 -3480 2340 -3480 {
lab=rA7}
N 2190 -3500 2340 -3500 {
lab=rA8}
N 2190 -3540 2340 -3540 {
lab=rA10}
N 2190 -3520 2340 -3520 {
lab=rA9}
N 2190 -3560 2340 -3560 {
lab=rA11}
N 2190 -3580 2340 -3580 {
lab=rA12}
N 2190 -3600 2340 -3600 {
lab=rA13}
N 2190 -3620 2340 -3620 {
lab=rA14}
N 2190 -3640 2340 -3640 {
lab=rA15}
N 2190 -3360 2340 -3360 {
lab=rA1}
N 2340 -3360 2400 -3360 {
lab=rA1}
N 2340 -3380 2400 -3380 {
lab=rA2}
N 2340 -3400 2400 -3400 {
lab=rA3}
N 2340 -3420 2400 -3420 {
lab=rA4}
N 2340 -3440 2400 -3440 {
lab=rA5}
N 2340 -3460 2400 -3460 {
lab=rA6}
N 2340 -3480 2400 -3480 {
lab=rA7}
N 2340 -3500 2400 -3500 {
lab=rA8}
N 2340 -3520 2400 -3520 {
lab=rA9}
N 2340 -3540 2400 -3540 {
lab=rA10}
N 2340 -3560 2400 -3560 {
lab=rA11}
N 2340 -3580 2400 -3580 {
lab=rA12}
N 2340 -3600 2400 -3600 {
lab=rA13}
N 2340 -3620 2400 -3620 {
lab=rA14}
N 2340 -3640 2400 -3640 {
lab=rA15}
N 2180 -3630 2180 -3290 {
lab=rA[0..15]
bus=true}
N 2700 -3340 2750 -3340 {
lab=rB0}
N 2700 -3360 2750 -3360 {
lab=rB1}
N 2820 -3350 2820 -3290 {
lab=rB[0..15]
bus=true}
N 2700 -3380 2750 -3380 {
lab=rB2}
N 2700 -3400 2750 -3400 {
lab=rB3}
N 2700 -3420 2750 -3420 {
lab=rB4}
N 2700 -3440 2750 -3440 {
lab=rB5}
N 2700 -3460 2750 -3460 {
lab=rB6}
N 2700 -3480 2750 -3480 {
lab=rB7}
N 2700 -3500 2750 -3500 {
lab=rB8}
N 2700 -3520 2750 -3520 {
lab=rB9}
N 2700 -3540 2750 -3540 {
lab=rB10}
N 2700 -3560 2750 -3560 {
lab=rB11}
N 2700 -3580 2750 -3580 {
lab=rB12}
N 2700 -3600 2750 -3600 {
lab=rB13}
N 2700 -3620 2750 -3620 {
lab=rB14}
N 2700 -3640 2750 -3640 {
lab=rB15}
N 2820 -3630 2820 -3350 {
lab=rB[0..15]
bus=true}
N 2340 -2660 2400 -2660 {
lab=cA0}
N 2340 -2680 2400 -2680 {
lab=cA1}
N 2340 -2700 2400 -2700 {
lab=cA2}
N 2340 -2720 2400 -2720 {
lab=cA3}
N 2340 -2740 2400 -2740 {
lab=cA4}
N 2340 -2760 2400 -2760 {
lab=cA5}
N 2340 -2780 2400 -2780 {
lab=cA6}
N 2340 -2800 2400 -2800 {
lab=cA7}
N 2340 -2820 2400 -2820 {
lab=cA8}
N 2340 -2840 2400 -2840 {
lab=cA9}
N 2340 -2860 2400 -2860 {
lab=cA10}
N 2340 -2880 2400 -2880 {
lab=cA11}
N 2340 -2900 2400 -2900 {
lab=cA12}
N 2340 -2920 2400 -2920 {
lab=cA13}
N 2340 -2940 2400 -2940 {
lab=cA14}
N 2340 -2960 2400 -2960 {
lab=cA15}
N 2330 -2950 2330 -2650 {bus=true
lab=cA[0..15]}
N 2330 -2650 2330 -2620 {bus=true
lab=cA[0..15]}
N 2700 -2660 2760 -2660 {
lab=cB0}
N 2700 -2680 2760 -2680 {
lab=cB1}
N 2700 -2700 2760 -2700 {
lab=cB2}
N 2700 -2720 2760 -2720 {
lab=cB3}
N 2700 -2740 2760 -2740 {
lab=cB4}
N 2700 -2760 2760 -2760 {
lab=cB5}
N 2700 -2780 2760 -2780 {
lab=cB6}
N 2700 -2800 2760 -2800 {
lab=cB7}
N 2700 -2820 2760 -2820 {
lab=cB8}
N 2700 -2840 2760 -2840 {
lab=cB9}
N 2700 -2860 2760 -2860 {
lab=cB10}
N 2700 -2880 2760 -2880 {
lab=cB11}
N 2700 -2900 2760 -2900 {
lab=cB12}
N 2700 -2920 2760 -2920 {
lab=cB13}
N 2700 -2940 2760 -2940 {
lab=cB14}
N 2700 -2960 2760 -2960 {
lab=cB15}
N 2770 -2950 2770 -2650 {bus=true
lab=cB[0..15]}
N 2770 -2650 2770 -2620 {bus=true
lab=cB[0..15]}
N 3040 -3330 3100 -3330 {
lab=rA0}
N 3450 -3330 3510 -3330 {
lab=rB0}
N 3450 -3350 3510 -3350 {
lab=rB1}
N 3450 -3370 3510 -3370 {
lab=rB2}
N 3450 -3390 3510 -3390 {
lab=rB3}
N 3450 -3410 3510 -3410 {
lab=rB4}
N 3450 -3430 3510 -3430 {
lab=rB5}
N 3450 -3450 3510 -3450 {
lab=rB6}
N 3450 -3470 3510 -3470 {
lab=rB7}
N 3450 -3490 3510 -3490 {
lab=rB8}
N 3450 -3510 3510 -3510 {
lab=rB9}
N 3450 -3530 3510 -3530 {
lab=rB10}
N 3450 -3550 3510 -3550 {
lab=rB11}
N 3450 -3570 3510 -3570 {
lab=rB12}
N 3450 -3590 3510 -3590 {
lab=rB13}
N 3450 -3610 3510 -3610 {
lab=rB14}
N 3450 -3630 3510 -3630 {
lab=rB15}
N 2890 -3330 3040 -3330 {
lab=rA0}
N 2890 -3370 3040 -3370 {
lab=rA2}
N 2890 -3390 3040 -3390 {
lab=rA3}
N 2890 -3410 3040 -3410 {
lab=rA4}
N 2890 -3430 3040 -3430 {
lab=rA5}
N 2890 -3450 3040 -3450 {
lab=rA6}
N 2890 -3470 3040 -3470 {
lab=rA7}
N 2890 -3490 3040 -3490 {
lab=rA8}
N 2890 -3530 3040 -3530 {
lab=rA10}
N 2890 -3510 3040 -3510 {
lab=rA9}
N 2890 -3550 3040 -3550 {
lab=rA11}
N 2890 -3570 3040 -3570 {
lab=rA12}
N 2890 -3590 3040 -3590 {
lab=rA13}
N 2890 -3610 3040 -3610 {
lab=rA14}
N 2890 -3630 3040 -3630 {
lab=rA15}
N 2890 -3350 3040 -3350 {
lab=rA1}
N 3040 -3350 3100 -3350 {
lab=rA1}
N 3040 -3370 3100 -3370 {
lab=rA2}
N 3040 -3390 3100 -3390 {
lab=rA3}
N 3040 -3410 3100 -3410 {
lab=rA4}
N 3040 -3430 3100 -3430 {
lab=rA5}
N 3040 -3450 3100 -3450 {
lab=rA6}
N 3040 -3470 3100 -3470 {
lab=rA7}
N 3040 -3490 3100 -3490 {
lab=rA8}
N 3040 -3510 3100 -3510 {
lab=rA9}
N 3040 -3530 3100 -3530 {
lab=rA10}
N 3040 -3550 3100 -3550 {
lab=rA11}
N 3040 -3570 3100 -3570 {
lab=rA12}
N 3040 -3590 3100 -3590 {
lab=rA13}
N 3040 -3610 3100 -3610 {
lab=rA14}
N 3040 -3630 3100 -3630 {
lab=rA15}
N 2880 -3620 2880 -3280 {
lab=rA[0..15]
bus=true}
N 3400 -3330 3450 -3330 {
lab=rB0}
N 3400 -3350 3450 -3350 {
lab=rB1}
N 3520 -3340 3520 -3280 {
lab=rB[0..15]
bus=true}
N 3400 -3370 3450 -3370 {
lab=rB2}
N 3400 -3390 3450 -3390 {
lab=rB3}
N 3400 -3410 3450 -3410 {
lab=rB4}
N 3400 -3430 3450 -3430 {
lab=rB5}
N 3400 -3450 3450 -3450 {
lab=rB6}
N 3400 -3470 3450 -3470 {
lab=rB7}
N 3400 -3490 3450 -3490 {
lab=rB8}
N 3400 -3510 3450 -3510 {
lab=rB9}
N 3400 -3530 3450 -3530 {
lab=rB10}
N 3400 -3550 3450 -3550 {
lab=rB11}
N 3400 -3570 3450 -3570 {
lab=rB12}
N 3400 -3590 3450 -3590 {
lab=rB13}
N 3400 -3610 3450 -3610 {
lab=rB14}
N 3400 -3630 3450 -3630 {
lab=rB15}
N 3520 -3620 3520 -3340 {
lab=rB[0..15]
bus=true}
N 3040 -2650 3100 -2650 {
lab=cA0}
N 3040 -2670 3100 -2670 {
lab=cA1}
N 3040 -2690 3100 -2690 {
lab=cA2}
N 3040 -2710 3100 -2710 {
lab=cA3}
N 3040 -2730 3100 -2730 {
lab=cA4}
N 3040 -2750 3100 -2750 {
lab=cA5}
N 3040 -2770 3100 -2770 {
lab=cA6}
N 3040 -2790 3100 -2790 {
lab=cA7}
N 3040 -2810 3100 -2810 {
lab=cA8}
N 3040 -2830 3100 -2830 {
lab=cA9}
N 3040 -2850 3100 -2850 {
lab=cA10}
N 3040 -2870 3100 -2870 {
lab=cA11}
N 3040 -2890 3100 -2890 {
lab=cA12}
N 3040 -2910 3100 -2910 {
lab=cA13}
N 3040 -2930 3100 -2930 {
lab=cA14}
N 3040 -2950 3100 -2950 {
lab=cA15}
N 3030 -2940 3030 -2640 {bus=true
lab=cA[0..15]}
N 3030 -2640 3030 -2610 {bus=true
lab=cA[0..15]}
N 3400 -2650 3460 -2650 {
lab=cB0}
N 3400 -2670 3460 -2670 {
lab=cB1}
N 3400 -2690 3460 -2690 {
lab=cB2}
N 3400 -2710 3460 -2710 {
lab=cB3}
N 3400 -2730 3460 -2730 {
lab=cB4}
N 3400 -2750 3460 -2750 {
lab=cB5}
N 3400 -2770 3460 -2770 {
lab=cB6}
N 3400 -2790 3460 -2790 {
lab=cB7}
N 3400 -2810 3460 -2810 {
lab=cB8}
N 3400 -2830 3460 -2830 {
lab=cB9}
N 3400 -2850 3460 -2850 {
lab=cB10}
N 3400 -2870 3460 -2870 {
lab=cB11}
N 3400 -2890 3460 -2890 {
lab=cB12}
N 3400 -2910 3460 -2910 {
lab=cB13}
N 3400 -2930 3460 -2930 {
lab=cB14}
N 3400 -2950 3460 -2950 {
lab=cB15}
N 3470 -2940 3470 -2640 {bus=true
lab=cB[0..15]}
N 3470 -2640 3470 -2610 {bus=true
lab=cB[0..15]}
N 3750 -3330 3810 -3330 {
lab=rA0}
N 4160 -3330 4220 -3330 {
lab=rB0}
N 4160 -3350 4220 -3350 {
lab=rB1}
N 4160 -3370 4220 -3370 {
lab=rB2}
N 4160 -3390 4220 -3390 {
lab=rB3}
N 4160 -3410 4220 -3410 {
lab=rB4}
N 4160 -3430 4220 -3430 {
lab=rB5}
N 4160 -3450 4220 -3450 {
lab=rB6}
N 4160 -3470 4220 -3470 {
lab=rB7}
N 4160 -3490 4220 -3490 {
lab=rB8}
N 4160 -3510 4220 -3510 {
lab=rB9}
N 4160 -3530 4220 -3530 {
lab=rB10}
N 4160 -3550 4220 -3550 {
lab=rB11}
N 4160 -3570 4220 -3570 {
lab=rB12}
N 4160 -3590 4220 -3590 {
lab=rB13}
N 4160 -3610 4220 -3610 {
lab=rB14}
N 4160 -3630 4220 -3630 {
lab=rB15}
N 3600 -3330 3750 -3330 {
lab=rA0}
N 3600 -3370 3750 -3370 {
lab=rA2}
N 3600 -3390 3750 -3390 {
lab=rA3}
N 3600 -3410 3750 -3410 {
lab=rA4}
N 3600 -3430 3750 -3430 {
lab=rA5}
N 3600 -3450 3750 -3450 {
lab=rA6}
N 3600 -3470 3750 -3470 {
lab=rA7}
N 3600 -3490 3750 -3490 {
lab=rA8}
N 3600 -3530 3750 -3530 {
lab=rA10}
N 3600 -3510 3750 -3510 {
lab=rA9}
N 3600 -3550 3750 -3550 {
lab=rA11}
N 3600 -3570 3750 -3570 {
lab=rA12}
N 3600 -3590 3750 -3590 {
lab=rA13}
N 3600 -3610 3750 -3610 {
lab=rA14}
N 3600 -3630 3750 -3630 {
lab=rA15}
N 3600 -3350 3750 -3350 {
lab=rA1}
N 3750 -3350 3810 -3350 {
lab=rA1}
N 3750 -3370 3810 -3370 {
lab=rA2}
N 3750 -3390 3810 -3390 {
lab=rA3}
N 3750 -3410 3810 -3410 {
lab=rA4}
N 3750 -3430 3810 -3430 {
lab=rA5}
N 3750 -3450 3810 -3450 {
lab=rA6}
N 3750 -3470 3810 -3470 {
lab=rA7}
N 3750 -3490 3810 -3490 {
lab=rA8}
N 3750 -3510 3810 -3510 {
lab=rA9}
N 3750 -3530 3810 -3530 {
lab=rA10}
N 3750 -3550 3810 -3550 {
lab=rA11}
N 3750 -3570 3810 -3570 {
lab=rA12}
N 3750 -3590 3810 -3590 {
lab=rA13}
N 3750 -3610 3810 -3610 {
lab=rA14}
N 3750 -3630 3810 -3630 {
lab=rA15}
N 3590 -3620 3590 -3280 {
lab=rA[0..15]
bus=true}
N 4110 -3330 4160 -3330 {
lab=rB0}
N 4110 -3350 4160 -3350 {
lab=rB1}
N 4230 -3340 4230 -3280 {
lab=rB[0..15]
bus=true}
N 4110 -3370 4160 -3370 {
lab=rB2}
N 4110 -3390 4160 -3390 {
lab=rB3}
N 4110 -3410 4160 -3410 {
lab=rB4}
N 4110 -3430 4160 -3430 {
lab=rB5}
N 4110 -3450 4160 -3450 {
lab=rB6}
N 4110 -3470 4160 -3470 {
lab=rB7}
N 4110 -3490 4160 -3490 {
lab=rB8}
N 4110 -3510 4160 -3510 {
lab=rB9}
N 4110 -3530 4160 -3530 {
lab=rB10}
N 4110 -3550 4160 -3550 {
lab=rB11}
N 4110 -3570 4160 -3570 {
lab=rB12}
N 4110 -3590 4160 -3590 {
lab=rB13}
N 4110 -3610 4160 -3610 {
lab=rB14}
N 4110 -3630 4160 -3630 {
lab=rB15}
N 4230 -3620 4230 -3340 {
lab=rB[0..15]
bus=true}
N 3750 -2650 3810 -2650 {
lab=cA0}
N 3750 -2670 3810 -2670 {
lab=cA1}
N 3750 -2690 3810 -2690 {
lab=cA2}
N 3750 -2710 3810 -2710 {
lab=cA3}
N 3750 -2730 3810 -2730 {
lab=cA4}
N 3750 -2750 3810 -2750 {
lab=cA5}
N 3750 -2770 3810 -2770 {
lab=cA6}
N 3750 -2790 3810 -2790 {
lab=cA7}
N 3750 -2810 3810 -2810 {
lab=cA8}
N 3750 -2830 3810 -2830 {
lab=cA9}
N 3750 -2850 3810 -2850 {
lab=cA10}
N 3750 -2870 3810 -2870 {
lab=cA11}
N 3750 -2890 3810 -2890 {
lab=cA12}
N 3750 -2910 3810 -2910 {
lab=cA13}
N 3750 -2930 3810 -2930 {
lab=cA14}
N 3750 -2950 3810 -2950 {
lab=cA15}
N 3740 -2940 3740 -2640 {bus=true
lab=cA[0..15]}
N 3740 -2640 3740 -2610 {bus=true
lab=cA[0..15]}
N 4110 -2650 4170 -2650 {
lab=cB0}
N 4110 -2670 4170 -2670 {
lab=cB1}
N 4110 -2690 4170 -2690 {
lab=cB2}
N 4110 -2710 4170 -2710 {
lab=cB3}
N 4110 -2730 4170 -2730 {
lab=cB4}
N 4110 -2750 4170 -2750 {
lab=cB5}
N 4110 -2770 4170 -2770 {
lab=cB6}
N 4110 -2790 4170 -2790 {
lab=cB7}
N 4110 -2810 4170 -2810 {
lab=cB8}
N 4110 -2830 4170 -2830 {
lab=cB9}
N 4110 -2850 4170 -2850 {
lab=cB10}
N 4110 -2870 4170 -2870 {
lab=cB11}
N 4110 -2890 4170 -2890 {
lab=cB12}
N 4110 -2910 4170 -2910 {
lab=cB13}
N 4110 -2930 4170 -2930 {
lab=cB14}
N 4110 -2950 4170 -2950 {
lab=cB15}
N 4180 -2940 4180 -2640 {bus=true
lab=cB[0..15]}
N 4180 -2640 4180 -2610 {bus=true
lab=cB[0..15]}
N 2340 -3920 2400 -3920 {
lab=col3_sel}
N 2340 -3940 2400 -3940 {
lab=row1_sel}
N 2340 -3700 2400 -3700 {
lab=Vcplus}
N 2340 -3720 2400 -3720 {
lab=Vcminus}
N 2340 -3740 2400 -3740 {
lab=Vref}
N 2340 -3760 2400 -3760 {
lab=Vref_comp}
N 2340 -3780 2400 -3780 {
lab=RISC_CLK}
N 2340 -3840 2400 -3840 {
lab=SAMPLE}
N 2340 -3820 2400 -3820 {
lab=Vrminus}
N 2340 -3800 2400 -3800 {
lab=Vrplus}
N 2340 -3880 2400 -3880 {
lab=WR}
N 2340 -3900 2400 -3900 {
lab=Vgnr}
N 2340 -3860 2400 -3860 {
lab=Vgpr}
N 3040 -3910 3100 -3910 {
lab=col4_sel}
N 3040 -3930 3100 -3930 {
lab=row1_sel}
N 3040 -3690 3100 -3690 {
lab=Vcplus}
N 3040 -3710 3100 -3710 {
lab=Vcminus}
N 3040 -3730 3100 -3730 {
lab=Vref}
N 3040 -3750 3100 -3750 {
lab=Vref_comp}
N 3040 -3770 3100 -3770 {
lab=RISC_CLK}
N 3040 -3830 3100 -3830 {
lab=SAMPLE}
N 3040 -3810 3100 -3810 {
lab=Vrminus}
N 3040 -3790 3100 -3790 {
lab=Vrplus}
N 3040 -3870 3100 -3870 {
lab=WR}
N 3040 -3890 3100 -3890 {
lab=Vgnr}
N 3040 -3850 3100 -3850 {
lab=Vgpr}
N 3750 -3910 3810 -3910 {
lab=col5_sel}
N 3750 -3930 3810 -3930 {
lab=row1_sel}
N 3750 -3690 3810 -3690 {
lab=Vcplus}
N 3750 -3710 3810 -3710 {
lab=Vcminus}
N 3750 -3730 3810 -3730 {
lab=Vref}
N 3750 -3750 3810 -3750 {
lab=Vref_comp}
N 3750 -3770 3810 -3770 {
lab=RISC_CLK}
N 3750 -3830 3810 -3830 {
lab=SAMPLE}
N 3750 -3810 3810 -3810 {
lab=Vrminus}
N 3750 -3790 3810 -3790 {
lab=Vrplus}
N 3750 -3870 3810 -3870 {
lab=WR}
N 3750 -3890 3810 -3890 {
lab=Vgnr}
N 3750 -3850 3810 -3850 {
lab=Vgpr}
N 190 -5340 250 -5340 {
lab=rA0}
N 600 -5340 660 -5340 {
lab=rB0}
N 600 -5360 660 -5360 {
lab=rB1}
N 600 -5380 660 -5380 {
lab=rB2}
N 600 -5400 660 -5400 {
lab=rB3}
N 600 -5420 660 -5420 {
lab=rB4}
N 600 -5440 660 -5440 {
lab=rB5}
N 600 -5460 660 -5460 {
lab=rB6}
N 600 -5480 660 -5480 {
lab=rB7}
N 600 -5500 660 -5500 {
lab=rB8}
N 600 -5520 660 -5520 {
lab=rB9}
N 600 -5540 660 -5540 {
lab=rB10}
N 600 -5560 660 -5560 {
lab=rB11}
N 600 -5580 660 -5580 {
lab=rB12}
N 600 -5600 660 -5600 {
lab=rB13}
N 600 -5620 660 -5620 {
lab=rB14}
N 600 -5640 660 -5640 {
lab=rB15}
N 190 -5000 250 -5000 {
lab=WL0}
N 190 -5020 250 -5020 {
lab=WL1}
N 190 -5040 250 -5040 {
lab=WL2}
N 190 -5060 250 -5060 {
lab=WL3}
N 190 -5080 250 -5080 {
lab=WL4}
N 190 -5100 250 -5100 {
lab=WL5}
N 190 -5120 250 -5120 {
lab=WL6}
N 190 -5140 250 -5140 {
lab=WL7}
N 190 -5160 250 -5160 {
lab=WL8}
N 190 -5180 250 -5180 {
lab=WL9}
N 190 -5200 250 -5200 {
lab=WL10}
N 190 -5220 250 -5220 {
lab=WL11}
N 190 -5240 250 -5240 {
lab=WL12}
N 190 -5260 250 -5260 {
lab=WL13}
N 190 -5280 250 -5280 {
lab=WL14}
N 190 -5300 250 -5300 {
lab=WL15}
N 190 -4660 250 -4660 {
lab=cA0}
N 190 -4680 250 -4680 {
lab=cA1}
N 190 -4700 250 -4700 {
lab=cA2}
N 190 -4720 250 -4720 {
lab=cA3}
N 190 -4740 250 -4740 {
lab=cA4}
N 190 -4760 250 -4760 {
lab=cA5}
N 190 -4780 250 -4780 {
lab=cA6}
N 190 -4800 250 -4800 {
lab=cA7}
N 190 -4820 250 -4820 {
lab=cA8}
N 190 -4840 250 -4840 {
lab=cA9}
N 190 -4860 250 -4860 {
lab=cA10}
N 190 -4880 250 -4880 {
lab=cA11}
N 190 -4900 250 -4900 {
lab=cA12}
N 190 -4920 250 -4920 {
lab=cA13}
N 190 -4940 250 -4940 {
lab=cA14}
N 190 -4960 250 -4960 {
lab=cA15}
N 190 -5920 250 -5920 {
lab=col0_sel}
N 190 -5940 250 -5940 {
lab=row2_sel}
N 190 -5880 250 -5880 {
lab=WR}
N 190 -5900 250 -5900 {
lab=Vgnr}
N 190 -5860 250 -5860 {
lab=Vgpr}
N 190 -5700 250 -5700 {
lab=Vcplus}
N 190 -5720 250 -5720 {
lab=Vcminus}
N 190 -5740 250 -5740 {
lab=Vref}
N 190 -5760 250 -5760 {
lab=Vref_comp}
N 190 -5780 250 -5780 {
lab=RISC_CLK}
N 550 -5880 610 -5880 {
lab=vssd1}
N 550 -5900 610 -5900 {
lab=vdda1}
N 550 -5920 610 -5920 {
lab=vccd1}
N 550 -5940 610 -5940 {
lab=latch_high0}
N 1970 -5930 2030 -5930 {
lab=latch_high2}
N 2700 -5880 2760 -5880 {
lab=vssd1}
N 2700 -5900 2760 -5900 {
lab=vdda1}
N 2700 -5920 2760 -5920 {
lab=vccd1}
N 2700 -5940 2760 -5940 {
lab=latch_high3}
N 3400 -5870 3460 -5870 {
lab=vssd1}
N 3400 -5890 3460 -5890 {
lab=vdda1}
N 3400 -5910 3460 -5910 {
lab=vccd1}
N 3400 -5930 3460 -5930 {
lab=latch_high4}
N 4110 -5870 4170 -5870 {
lab=vssd1}
N 4110 -5890 4170 -5890 {
lab=vdda1}
N 4110 -5910 4170 -5910 {
lab=vccd1}
N 4110 -5930 4170 -5930 {
lab=latch_high5}
N 130 -5000 190 -5000 {
lab=WL0}
N 130 -5020 190 -5020 {
lab=WL1}
N 130 -5040 190 -5040 {
lab=WL2}
N 130 -5060 190 -5060 {
lab=WL3}
N 130 -5080 190 -5080 {
lab=WL4}
N 130 -5100 190 -5100 {
lab=WL5}
N 130 -5120 190 -5120 {
lab=WL6}
N 130 -5140 190 -5140 {
lab=WL7}
N 130 -5160 190 -5160 {
lab=WL8}
N 130 -5180 190 -5180 {
lab=WL9}
N 130 -5200 190 -5200 {
lab=WL10}
N 130 -5220 190 -5220 {
lab=WL11}
N 130 -5240 190 -5240 {
lab=WL12}
N 130 -5260 190 -5260 {
lab=WL13}
N 130 -5280 190 -5280 {
lab=WL14}
N 130 -5300 190 -5300 {
lab=WL15}
N 70 -5000 130 -5000 {
lab=WL0}
N 70 -5020 130 -5020 {
lab=WL1}
N 70 -5040 130 -5040 {
lab=WL2}
N 70 -5060 130 -5060 {
lab=WL3}
N 70 -5080 130 -5080 {
lab=WL4}
N 70 -5100 130 -5100 {
lab=WL5}
N 70 -5120 130 -5120 {
lab=WL6}
N 70 -5140 130 -5140 {
lab=WL7}
N 70 -5160 130 -5160 {
lab=WL8}
N 70 -5180 130 -5180 {
lab=WL9}
N 70 -5200 130 -5200 {
lab=WL10}
N 70 -5220 130 -5220 {
lab=WL11}
N 70 -5240 130 -5240 {
lab=WL12}
N 70 -5260 130 -5260 {
lab=WL13}
N 70 -5280 130 -5280 {
lab=WL14}
N 70 -5300 130 -5300 {
lab=WL15}
N 60 -5290 60 -4990 {bus=true
lab=WL[0..15]}
N 60 -4990 60 -4960 {bus=true
lab=WL[0..15]}
N 910 -5000 970 -5000 {
lab=WL0}
N 910 -5020 970 -5020 {
lab=WL1}
N 910 -5040 970 -5040 {
lab=WL2}
N 910 -5060 970 -5060 {
lab=WL3}
N 910 -5080 970 -5080 {
lab=WL4}
N 910 -5100 970 -5100 {
lab=WL5}
N 910 -5120 970 -5120 {
lab=WL6}
N 910 -5140 970 -5140 {
lab=WL7}
N 910 -5160 970 -5160 {
lab=WL8}
N 910 -5180 970 -5180 {
lab=WL9}
N 910 -5200 970 -5200 {
lab=WL10}
N 910 -5220 970 -5220 {
lab=WL11}
N 910 -5240 970 -5240 {
lab=WL12}
N 910 -5260 970 -5260 {
lab=WL13}
N 910 -5280 970 -5280 {
lab=WL14}
N 910 -5300 970 -5300 {
lab=WL15}
N 850 -5000 910 -5000 {
lab=WL0}
N 850 -5020 910 -5020 {
lab=WL1}
N 850 -5040 910 -5040 {
lab=WL2}
N 850 -5060 910 -5060 {
lab=WL3}
N 850 -5080 910 -5080 {
lab=WL4}
N 850 -5100 910 -5100 {
lab=WL5}
N 850 -5120 910 -5120 {
lab=WL6}
N 850 -5140 910 -5140 {
lab=WL7}
N 850 -5160 910 -5160 {
lab=WL8}
N 850 -5180 910 -5180 {
lab=WL9}
N 850 -5200 910 -5200 {
lab=WL10}
N 850 -5220 910 -5220 {
lab=WL11}
N 850 -5240 910 -5240 {
lab=WL12}
N 850 -5260 910 -5260 {
lab=WL13}
N 850 -5280 910 -5280 {
lab=WL14}
N 850 -5300 910 -5300 {
lab=WL15}
N 790 -5000 850 -5000 {
lab=WL0}
N 790 -5020 850 -5020 {
lab=WL1}
N 790 -5040 850 -5040 {
lab=WL2}
N 790 -5060 850 -5060 {
lab=WL3}
N 790 -5080 850 -5080 {
lab=WL4}
N 790 -5100 850 -5100 {
lab=WL5}
N 790 -5120 850 -5120 {
lab=WL6}
N 790 -5140 850 -5140 {
lab=WL7}
N 790 -5160 850 -5160 {
lab=WL8}
N 790 -5180 850 -5180 {
lab=WL9}
N 790 -5200 850 -5200 {
lab=WL10}
N 790 -5220 850 -5220 {
lab=WL11}
N 790 -5240 850 -5240 {
lab=WL12}
N 790 -5260 850 -5260 {
lab=WL13}
N 790 -5280 850 -5280 {
lab=WL14}
N 790 -5300 850 -5300 {
lab=WL15}
N 780 -5290 780 -4990 {bus=true
lab=WL[0..15]}
N 780 -4990 780 -4960 {bus=true
lab=WL[0..15]}
N 1610 -4990 1670 -4990 {
lab=WL0}
N 1610 -5010 1670 -5010 {
lab=WL1}
N 1610 -5030 1670 -5030 {
lab=WL2}
N 1610 -5050 1670 -5050 {
lab=WL3}
N 1610 -5070 1670 -5070 {
lab=WL4}
N 1610 -5090 1670 -5090 {
lab=WL5}
N 1610 -5110 1670 -5110 {
lab=WL6}
N 1610 -5130 1670 -5130 {
lab=WL7}
N 1610 -5150 1670 -5150 {
lab=WL8}
N 1610 -5170 1670 -5170 {
lab=WL9}
N 1610 -5190 1670 -5190 {
lab=WL10}
N 1610 -5210 1670 -5210 {
lab=WL11}
N 1610 -5230 1670 -5230 {
lab=WL12}
N 1610 -5250 1670 -5250 {
lab=WL13}
N 1610 -5270 1670 -5270 {
lab=WL14}
N 1610 -5290 1670 -5290 {
lab=WL15}
N 1550 -4990 1610 -4990 {
lab=WL0}
N 1550 -5010 1610 -5010 {
lab=WL1}
N 1550 -5030 1610 -5030 {
lab=WL2}
N 1550 -5050 1610 -5050 {
lab=WL3}
N 1550 -5070 1610 -5070 {
lab=WL4}
N 1550 -5090 1610 -5090 {
lab=WL5}
N 1550 -5110 1610 -5110 {
lab=WL6}
N 1550 -5130 1610 -5130 {
lab=WL7}
N 1550 -5150 1610 -5150 {
lab=WL8}
N 1550 -5170 1610 -5170 {
lab=WL9}
N 1550 -5190 1610 -5190 {
lab=WL10}
N 1550 -5210 1610 -5210 {
lab=WL11}
N 1550 -5230 1610 -5230 {
lab=WL12}
N 1550 -5250 1610 -5250 {
lab=WL13}
N 1550 -5270 1610 -5270 {
lab=WL14}
N 1550 -5290 1610 -5290 {
lab=WL15}
N 1490 -4990 1550 -4990 {
lab=WL0}
N 1490 -5010 1550 -5010 {
lab=WL1}
N 1490 -5030 1550 -5030 {
lab=WL2}
N 1490 -5050 1550 -5050 {
lab=WL3}
N 1490 -5070 1550 -5070 {
lab=WL4}
N 1490 -5090 1550 -5090 {
lab=WL5}
N 1490 -5110 1550 -5110 {
lab=WL6}
N 1490 -5130 1550 -5130 {
lab=WL7}
N 1490 -5150 1550 -5150 {
lab=WL8}
N 1490 -5170 1550 -5170 {
lab=WL9}
N 1490 -5190 1550 -5190 {
lab=WL10}
N 1490 -5210 1550 -5210 {
lab=WL11}
N 1490 -5230 1550 -5230 {
lab=WL12}
N 1490 -5250 1550 -5250 {
lab=WL13}
N 1490 -5270 1550 -5270 {
lab=WL14}
N 1490 -5290 1550 -5290 {
lab=WL15}
N 1480 -5280 1480 -4980 {bus=true
lab=WL[0..15]}
N 1480 -4980 1480 -4950 {bus=true
lab=WL[0..15]}
N 2340 -5000 2400 -5000 {
lab=WL0}
N 2340 -5020 2400 -5020 {
lab=WL1}
N 2340 -5040 2400 -5040 {
lab=WL2}
N 2340 -5060 2400 -5060 {
lab=WL3}
N 2340 -5080 2400 -5080 {
lab=WL4}
N 2340 -5100 2400 -5100 {
lab=WL5}
N 2340 -5120 2400 -5120 {
lab=WL6}
N 2340 -5140 2400 -5140 {
lab=WL7}
N 2340 -5160 2400 -5160 {
lab=WL8}
N 2340 -5180 2400 -5180 {
lab=WL9}
N 2340 -5200 2400 -5200 {
lab=WL10}
N 2340 -5220 2400 -5220 {
lab=WL11}
N 2340 -5240 2400 -5240 {
lab=WL12}
N 2340 -5260 2400 -5260 {
lab=WL13}
N 2340 -5280 2400 -5280 {
lab=WL14}
N 2340 -5300 2400 -5300 {
lab=WL15}
N 2280 -5000 2340 -5000 {
lab=WL0}
N 2280 -5020 2340 -5020 {
lab=WL1}
N 2280 -5040 2340 -5040 {
lab=WL2}
N 2280 -5060 2340 -5060 {
lab=WL3}
N 2280 -5080 2340 -5080 {
lab=WL4}
N 2280 -5100 2340 -5100 {
lab=WL5}
N 2280 -5120 2340 -5120 {
lab=WL6}
N 2280 -5140 2340 -5140 {
lab=WL7}
N 2280 -5160 2340 -5160 {
lab=WL8}
N 2280 -5180 2340 -5180 {
lab=WL9}
N 2280 -5200 2340 -5200 {
lab=WL10}
N 2280 -5220 2340 -5220 {
lab=WL11}
N 2280 -5240 2340 -5240 {
lab=WL12}
N 2280 -5260 2340 -5260 {
lab=WL13}
N 2280 -5280 2340 -5280 {
lab=WL14}
N 2280 -5300 2340 -5300 {
lab=WL15}
N 2220 -5000 2280 -5000 {
lab=WL0}
N 2220 -5020 2280 -5020 {
lab=WL1}
N 2220 -5040 2280 -5040 {
lab=WL2}
N 2220 -5060 2280 -5060 {
lab=WL3}
N 2220 -5080 2280 -5080 {
lab=WL4}
N 2220 -5100 2280 -5100 {
lab=WL5}
N 2220 -5120 2280 -5120 {
lab=WL6}
N 2220 -5140 2280 -5140 {
lab=WL7}
N 2220 -5160 2280 -5160 {
lab=WL8}
N 2220 -5180 2280 -5180 {
lab=WL9}
N 2220 -5200 2280 -5200 {
lab=WL10}
N 2220 -5220 2280 -5220 {
lab=WL11}
N 2220 -5240 2280 -5240 {
lab=WL12}
N 2220 -5260 2280 -5260 {
lab=WL13}
N 2220 -5280 2280 -5280 {
lab=WL14}
N 2220 -5300 2280 -5300 {
lab=WL15}
N 2210 -5290 2210 -4990 {bus=true
lab=WL[0..15]}
N 2210 -4990 2210 -4960 {bus=true
lab=WL[0..15]}
N 3040 -4990 3100 -4990 {
lab=WL0}
N 3040 -5010 3100 -5010 {
lab=WL1}
N 3040 -5030 3100 -5030 {
lab=WL2}
N 3040 -5050 3100 -5050 {
lab=WL3}
N 3040 -5070 3100 -5070 {
lab=WL4}
N 3040 -5090 3100 -5090 {
lab=WL5}
N 3040 -5110 3100 -5110 {
lab=WL6}
N 3040 -5130 3100 -5130 {
lab=WL7}
N 3040 -5150 3100 -5150 {
lab=WL8}
N 3040 -5170 3100 -5170 {
lab=WL9}
N 3040 -5190 3100 -5190 {
lab=WL10}
N 3040 -5210 3100 -5210 {
lab=WL11}
N 3040 -5230 3100 -5230 {
lab=WL12}
N 3040 -5250 3100 -5250 {
lab=WL13}
N 3040 -5270 3100 -5270 {
lab=WL14}
N 3040 -5290 3100 -5290 {
lab=WL15}
N 2980 -4990 3040 -4990 {
lab=WL0}
N 2980 -5010 3040 -5010 {
lab=WL1}
N 2980 -5030 3040 -5030 {
lab=WL2}
N 2980 -5050 3040 -5050 {
lab=WL3}
N 2980 -5070 3040 -5070 {
lab=WL4}
N 2980 -5090 3040 -5090 {
lab=WL5}
N 2980 -5110 3040 -5110 {
lab=WL6}
N 2980 -5130 3040 -5130 {
lab=WL7}
N 2980 -5150 3040 -5150 {
lab=WL8}
N 2980 -5170 3040 -5170 {
lab=WL9}
N 2980 -5190 3040 -5190 {
lab=WL10}
N 2980 -5210 3040 -5210 {
lab=WL11}
N 2980 -5230 3040 -5230 {
lab=WL12}
N 2980 -5250 3040 -5250 {
lab=WL13}
N 2980 -5270 3040 -5270 {
lab=WL14}
N 2980 -5290 3040 -5290 {
lab=WL15}
N 2920 -4990 2980 -4990 {
lab=WL0}
N 2920 -5010 2980 -5010 {
lab=WL1}
N 2920 -5030 2980 -5030 {
lab=WL2}
N 2920 -5050 2980 -5050 {
lab=WL3}
N 2920 -5070 2980 -5070 {
lab=WL4}
N 2920 -5090 2980 -5090 {
lab=WL5}
N 2920 -5110 2980 -5110 {
lab=WL6}
N 2920 -5130 2980 -5130 {
lab=WL7}
N 2920 -5150 2980 -5150 {
lab=WL8}
N 2920 -5170 2980 -5170 {
lab=WL9}
N 2920 -5190 2980 -5190 {
lab=WL10}
N 2920 -5210 2980 -5210 {
lab=WL11}
N 2920 -5230 2980 -5230 {
lab=WL12}
N 2920 -5250 2980 -5250 {
lab=WL13}
N 2920 -5270 2980 -5270 {
lab=WL14}
N 2920 -5290 2980 -5290 {
lab=WL15}
N 2910 -5280 2910 -4980 {bus=true
lab=WL[0..15]}
N 2910 -4980 2910 -4950 {bus=true
lab=WL[0..15]}
N 3750 -4990 3810 -4990 {
lab=WL0}
N 3750 -5010 3810 -5010 {
lab=WL1}
N 3750 -5030 3810 -5030 {
lab=WL2}
N 3750 -5050 3810 -5050 {
lab=WL3}
N 3750 -5070 3810 -5070 {
lab=WL4}
N 3750 -5090 3810 -5090 {
lab=WL5}
N 3750 -5110 3810 -5110 {
lab=WL6}
N 3750 -5130 3810 -5130 {
lab=WL7}
N 3750 -5150 3810 -5150 {
lab=WL8}
N 3750 -5170 3810 -5170 {
lab=WL9}
N 3750 -5190 3810 -5190 {
lab=WL10}
N 3750 -5210 3810 -5210 {
lab=WL11}
N 3750 -5230 3810 -5230 {
lab=WL12}
N 3750 -5250 3810 -5250 {
lab=WL13}
N 3750 -5270 3810 -5270 {
lab=WL14}
N 3750 -5290 3810 -5290 {
lab=WL15}
N 3690 -4990 3750 -4990 {
lab=WL0}
N 3690 -5010 3750 -5010 {
lab=WL1}
N 3690 -5030 3750 -5030 {
lab=WL2}
N 3690 -5050 3750 -5050 {
lab=WL3}
N 3690 -5070 3750 -5070 {
lab=WL4}
N 3690 -5090 3750 -5090 {
lab=WL5}
N 3690 -5110 3750 -5110 {
lab=WL6}
N 3690 -5130 3750 -5130 {
lab=WL7}
N 3690 -5150 3750 -5150 {
lab=WL8}
N 3690 -5170 3750 -5170 {
lab=WL9}
N 3690 -5190 3750 -5190 {
lab=WL10}
N 3690 -5210 3750 -5210 {
lab=WL11}
N 3690 -5230 3750 -5230 {
lab=WL12}
N 3690 -5250 3750 -5250 {
lab=WL13}
N 3690 -5270 3750 -5270 {
lab=WL14}
N 3690 -5290 3750 -5290 {
lab=WL15}
N 3630 -4990 3690 -4990 {
lab=WL0}
N 3630 -5010 3690 -5010 {
lab=WL1}
N 3630 -5030 3690 -5030 {
lab=WL2}
N 3630 -5050 3690 -5050 {
lab=WL3}
N 3630 -5070 3690 -5070 {
lab=WL4}
N 3630 -5090 3690 -5090 {
lab=WL5}
N 3630 -5110 3690 -5110 {
lab=WL6}
N 3630 -5130 3690 -5130 {
lab=WL7}
N 3630 -5150 3690 -5150 {
lab=WL8}
N 3630 -5170 3690 -5170 {
lab=WL9}
N 3630 -5190 3690 -5190 {
lab=WL10}
N 3630 -5210 3690 -5210 {
lab=WL11}
N 3630 -5230 3690 -5230 {
lab=WL12}
N 3630 -5250 3690 -5250 {
lab=WL13}
N 3630 -5270 3690 -5270 {
lab=WL14}
N 3630 -5290 3690 -5290 {
lab=WL15}
N 3620 -5280 3620 -4980 {bus=true
lab=WL[0..15]}
N 3620 -4980 3620 -4950 {bus=true
lab=WL[0..15]}
N 40 -5340 190 -5340 {
lab=rA0}
N 40 -5380 190 -5380 {
lab=rA2}
N 40 -5400 190 -5400 {
lab=rA3}
N 40 -5420 190 -5420 {
lab=rA4}
N 40 -5440 190 -5440 {
lab=rA5}
N 40 -5460 190 -5460 {
lab=rA6}
N 40 -5480 190 -5480 {
lab=rA7}
N 40 -5500 190 -5500 {
lab=rA8}
N 40 -5540 190 -5540 {
lab=rA10}
N 40 -5520 190 -5520 {
lab=rA9}
N 40 -5560 190 -5560 {
lab=rA11}
N 40 -5580 190 -5580 {
lab=rA12}
N 40 -5600 190 -5600 {
lab=rA13}
N 40 -5620 190 -5620 {
lab=rA14}
N 40 -5640 190 -5640 {
lab=rA15}
N 190 -5840 250 -5840 {
lab=SAMPLE}
N 190 -5820 250 -5820 {
lab=Vrminus}
N 190 -5800 250 -5800 {
lab=Vrplus}
N 40 -5360 190 -5360 {
lab=rA1}
N 190 -5360 250 -5360 {
lab=rA1}
N 190 -5380 250 -5380 {
lab=rA2}
N 190 -5400 250 -5400 {
lab=rA3}
N 190 -5420 250 -5420 {
lab=rA4}
N 190 -5440 250 -5440 {
lab=rA5}
N 190 -5460 250 -5460 {
lab=rA6}
N 190 -5480 250 -5480 {
lab=rA7}
N 190 -5500 250 -5500 {
lab=rA8}
N 190 -5520 250 -5520 {
lab=rA9}
N 190 -5540 250 -5540 {
lab=rA10}
N 190 -5560 250 -5560 {
lab=rA11}
N 190 -5580 250 -5580 {
lab=rA12}
N 190 -5600 250 -5600 {
lab=rA13}
N 190 -5620 250 -5620 {
lab=rA14}
N 190 -5640 250 -5640 {
lab=rA15}
N 30 -5630 30 -5290 {
lab=rA[0..15]
bus=true}
N 550 -5340 600 -5340 {
lab=rB0}
N 550 -5360 600 -5360 {
lab=rB1}
N 670 -5350 670 -5290 {
lab=rB[0..15]
bus=true}
N 550 -5380 600 -5380 {
lab=rB2}
N 550 -5400 600 -5400 {
lab=rB3}
N 550 -5420 600 -5420 {
lab=rB4}
N 550 -5440 600 -5440 {
lab=rB5}
N 550 -5460 600 -5460 {
lab=rB6}
N 550 -5480 600 -5480 {
lab=rB7}
N 550 -5500 600 -5500 {
lab=rB8}
N 550 -5520 600 -5520 {
lab=rB9}
N 550 -5540 600 -5540 {
lab=rB10}
N 550 -5560 600 -5560 {
lab=rB11}
N 550 -5580 600 -5580 {
lab=rB12}
N 550 -5600 600 -5600 {
lab=rB13}
N 550 -5620 600 -5620 {
lab=rB14}
N 550 -5640 600 -5640 {
lab=rB15}
N 670 -5630 670 -5350 {
lab=rB[0..15]
bus=true}
N 180 -4950 180 -4650 {bus=true
lab=cA[0..15]}
N 180 -4650 180 -4620 {bus=true
lab=cA[0..15]}
N 550 -4660 610 -4660 {
lab=cB0}
N 550 -4680 610 -4680 {
lab=cB1}
N 550 -4700 610 -4700 {
lab=cB2}
N 550 -4720 610 -4720 {
lab=cB3}
N 550 -4740 610 -4740 {
lab=cB4}
N 550 -4760 610 -4760 {
lab=cB5}
N 550 -4780 610 -4780 {
lab=cB6}
N 550 -4800 610 -4800 {
lab=cB7}
N 550 -4820 610 -4820 {
lab=cB8}
N 550 -4840 610 -4840 {
lab=cB9}
N 550 -4860 610 -4860 {
lab=cB10}
N 550 -4880 610 -4880 {
lab=cB11}
N 550 -4900 610 -4900 {
lab=cB12}
N 550 -4920 610 -4920 {
lab=cB13}
N 550 -4940 610 -4940 {
lab=cB14}
N 550 -4960 610 -4960 {
lab=cB15}
N 620 -4950 620 -4650 {bus=true
lab=cB[0..15]}
N 620 -4650 620 -4620 {bus=true
lab=cB[0..15]}
N 910 -5340 970 -5340 {
lab=rA0}
N 1320 -5340 1380 -5340 {
lab=rB0}
N 1320 -5360 1380 -5360 {
lab=rB1}
N 1320 -5380 1380 -5380 {
lab=rB2}
N 1320 -5400 1380 -5400 {
lab=rB3}
N 1320 -5420 1380 -5420 {
lab=rB4}
N 1320 -5440 1380 -5440 {
lab=rB5}
N 1320 -5460 1380 -5460 {
lab=rB6}
N 1320 -5480 1380 -5480 {
lab=rB7}
N 1320 -5500 1380 -5500 {
lab=rB8}
N 1320 -5520 1380 -5520 {
lab=rB9}
N 1320 -5540 1380 -5540 {
lab=rB10}
N 1320 -5560 1380 -5560 {
lab=rB11}
N 1320 -5580 1380 -5580 {
lab=rB12}
N 1320 -5600 1380 -5600 {
lab=rB13}
N 1320 -5620 1380 -5620 {
lab=rB14}
N 1320 -5640 1380 -5640 {
lab=rB15}
N 910 -5920 970 -5920 {
lab=col1_sel}
N 910 -5940 970 -5940 {
lab=row2_sel}
N 910 -5700 970 -5700 {
lab=Vcplus}
N 910 -5720 970 -5720 {
lab=Vcminus}
N 910 -5740 970 -5740 {
lab=Vref}
N 910 -5760 970 -5760 {
lab=Vref_comp}
N 910 -5780 970 -5780 {
lab=RISC_CLK}
N 1270 -5880 1330 -5880 {
lab=vssd1}
N 1270 -5900 1330 -5900 {
lab=vdda1}
N 1270 -5920 1330 -5920 {
lab=vccd1}
N 1270 -5940 1330 -5940 {
lab=latch_high1}
N 760 -5340 910 -5340 {
lab=rA0}
N 760 -5380 910 -5380 {
lab=rA2}
N 760 -5400 910 -5400 {
lab=rA3}
N 760 -5420 910 -5420 {
lab=rA4}
N 760 -5440 910 -5440 {
lab=rA5}
N 760 -5460 910 -5460 {
lab=rA6}
N 760 -5480 910 -5480 {
lab=rA7}
N 760 -5500 910 -5500 {
lab=rA8}
N 760 -5540 910 -5540 {
lab=rA10}
N 760 -5520 910 -5520 {
lab=rA9}
N 760 -5560 910 -5560 {
lab=rA11}
N 760 -5580 910 -5580 {
lab=rA12}
N 760 -5600 910 -5600 {
lab=rA13}
N 760 -5620 910 -5620 {
lab=rA14}
N 760 -5640 910 -5640 {
lab=rA15}
N 910 -5840 970 -5840 {
lab=SAMPLE}
N 910 -5820 970 -5820 {
lab=Vrminus}
N 910 -5800 970 -5800 {
lab=Vrplus}
N 760 -5360 910 -5360 {
lab=rA1}
N 910 -5360 970 -5360 {
lab=rA1}
N 910 -5380 970 -5380 {
lab=rA2}
N 910 -5400 970 -5400 {
lab=rA3}
N 910 -5420 970 -5420 {
lab=rA4}
N 910 -5440 970 -5440 {
lab=rA5}
N 910 -5460 970 -5460 {
lab=rA6}
N 910 -5480 970 -5480 {
lab=rA7}
N 910 -5500 970 -5500 {
lab=rA8}
N 910 -5520 970 -5520 {
lab=rA9}
N 910 -5540 970 -5540 {
lab=rA10}
N 910 -5560 970 -5560 {
lab=rA11}
N 910 -5580 970 -5580 {
lab=rA12}
N 910 -5600 970 -5600 {
lab=rA13}
N 910 -5620 970 -5620 {
lab=rA14}
N 910 -5640 970 -5640 {
lab=rA15}
N 750 -5630 750 -5290 {
lab=rA[0..15]
bus=true}
N 1270 -5340 1320 -5340 {
lab=rB0}
N 1270 -5360 1320 -5360 {
lab=rB1}
N 1390 -5350 1390 -5290 {
lab=rB[0..15]
bus=true}
N 1270 -5380 1320 -5380 {
lab=rB2}
N 1270 -5400 1320 -5400 {
lab=rB3}
N 1270 -5420 1320 -5420 {
lab=rB4}
N 1270 -5440 1320 -5440 {
lab=rB5}
N 1270 -5460 1320 -5460 {
lab=rB6}
N 1270 -5480 1320 -5480 {
lab=rB7}
N 1270 -5500 1320 -5500 {
lab=rB8}
N 1270 -5520 1320 -5520 {
lab=rB9}
N 1270 -5540 1320 -5540 {
lab=rB10}
N 1270 -5560 1320 -5560 {
lab=rB11}
N 1270 -5580 1320 -5580 {
lab=rB12}
N 1270 -5600 1320 -5600 {
lab=rB13}
N 1270 -5620 1320 -5620 {
lab=rB14}
N 1270 -5640 1320 -5640 {
lab=rB15}
N 1390 -5630 1390 -5350 {
lab=rB[0..15]
bus=true}
N 910 -5880 970 -5880 {
lab=WR}
N 910 -5900 970 -5900 {
lab=Vgnr}
N 910 -5860 970 -5860 {
lab=Vgpr}
N 1610 -5910 1670 -5910 {
lab=col2_sel}
N 1610 -5930 1670 -5930 {
lab=row2_sel}
N 1610 -5690 1670 -5690 {
lab=Vcplus}
N 1610 -5710 1670 -5710 {
lab=Vcminus}
N 1610 -5730 1670 -5730 {
lab=Vref}
N 1610 -5750 1670 -5750 {
lab=Vref_comp}
N 1610 -5770 1670 -5770 {
lab=RISC_CLK}
N 1610 -5830 1670 -5830 {
lab=SAMPLE}
N 1610 -5810 1670 -5810 {
lab=Vrminus}
N 1610 -5790 1670 -5790 {
lab=Vrplus}
N 1610 -5870 1670 -5870 {
lab=WR}
N 1610 -5890 1670 -5890 {
lab=Vgnr}
N 1610 -5850 1670 -5850 {
lab=Vgpr}
N 1970 -5870 2030 -5870 {
lab=vssd1}
N 1970 -5890 2030 -5890 {
lab=vdda1}
N 1970 -5910 2030 -5910 {
lab=vccd1}
N 1610 -5330 1670 -5330 {
lab=rA0}
N 2020 -5330 2080 -5330 {
lab=rB0}
N 2020 -5350 2080 -5350 {
lab=rB1}
N 2020 -5370 2080 -5370 {
lab=rB2}
N 2020 -5390 2080 -5390 {
lab=rB3}
N 2020 -5410 2080 -5410 {
lab=rB4}
N 2020 -5430 2080 -5430 {
lab=rB5}
N 2020 -5450 2080 -5450 {
lab=rB6}
N 2020 -5470 2080 -5470 {
lab=rB7}
N 2020 -5490 2080 -5490 {
lab=rB8}
N 2020 -5510 2080 -5510 {
lab=rB9}
N 2020 -5530 2080 -5530 {
lab=rB10}
N 2020 -5550 2080 -5550 {
lab=rB11}
N 2020 -5570 2080 -5570 {
lab=rB12}
N 2020 -5590 2080 -5590 {
lab=rB13}
N 2020 -5610 2080 -5610 {
lab=rB14}
N 2020 -5630 2080 -5630 {
lab=rB15}
N 1460 -5330 1610 -5330 {
lab=rA0}
N 1460 -5370 1610 -5370 {
lab=rA2}
N 1460 -5390 1610 -5390 {
lab=rA3}
N 1460 -5410 1610 -5410 {
lab=rA4}
N 1460 -5430 1610 -5430 {
lab=rA5}
N 1460 -5450 1610 -5450 {
lab=rA6}
N 1460 -5470 1610 -5470 {
lab=rA7}
N 1460 -5490 1610 -5490 {
lab=rA8}
N 1460 -5530 1610 -5530 {
lab=rA10}
N 1460 -5510 1610 -5510 {
lab=rA9}
N 1460 -5550 1610 -5550 {
lab=rA11}
N 1460 -5570 1610 -5570 {
lab=rA12}
N 1460 -5590 1610 -5590 {
lab=rA13}
N 1460 -5610 1610 -5610 {
lab=rA14}
N 1460 -5630 1610 -5630 {
lab=rA15}
N 1460 -5350 1610 -5350 {
lab=rA1}
N 1610 -5350 1670 -5350 {
lab=rA1}
N 1610 -5370 1670 -5370 {
lab=rA2}
N 1610 -5390 1670 -5390 {
lab=rA3}
N 1610 -5410 1670 -5410 {
lab=rA4}
N 1610 -5430 1670 -5430 {
lab=rA5}
N 1610 -5450 1670 -5450 {
lab=rA6}
N 1610 -5470 1670 -5470 {
lab=rA7}
N 1610 -5490 1670 -5490 {
lab=rA8}
N 1610 -5510 1670 -5510 {
lab=rA9}
N 1610 -5530 1670 -5530 {
lab=rA10}
N 1610 -5550 1670 -5550 {
lab=rA11}
N 1610 -5570 1670 -5570 {
lab=rA12}
N 1610 -5590 1670 -5590 {
lab=rA13}
N 1610 -5610 1670 -5610 {
lab=rA14}
N 1610 -5630 1670 -5630 {
lab=rA15}
N 1450 -5620 1450 -5280 {
lab=rA[0..15]
bus=true}
N 1970 -5330 2020 -5330 {
lab=rB0}
N 1970 -5350 2020 -5350 {
lab=rB1}
N 2090 -5340 2090 -5280 {
lab=rB[0..15]
bus=true}
N 1970 -5370 2020 -5370 {
lab=rB2}
N 1970 -5390 2020 -5390 {
lab=rB3}
N 1970 -5410 2020 -5410 {
lab=rB4}
N 1970 -5430 2020 -5430 {
lab=rB5}
N 1970 -5450 2020 -5450 {
lab=rB6}
N 1970 -5470 2020 -5470 {
lab=rB7}
N 1970 -5490 2020 -5490 {
lab=rB8}
N 1970 -5510 2020 -5510 {
lab=rB9}
N 1970 -5530 2020 -5530 {
lab=rB10}
N 1970 -5550 2020 -5550 {
lab=rB11}
N 1970 -5570 2020 -5570 {
lab=rB12}
N 1970 -5590 2020 -5590 {
lab=rB13}
N 1970 -5610 2020 -5610 {
lab=rB14}
N 1970 -5630 2020 -5630 {
lab=rB15}
N 2090 -5620 2090 -5340 {
lab=rB[0..15]
bus=true}
N 910 -4660 970 -4660 {
lab=cA0}
N 910 -4680 970 -4680 {
lab=cA1}
N 910 -4700 970 -4700 {
lab=cA2}
N 910 -4720 970 -4720 {
lab=cA3}
N 910 -4740 970 -4740 {
lab=cA4}
N 910 -4760 970 -4760 {
lab=cA5}
N 910 -4780 970 -4780 {
lab=cA6}
N 910 -4800 970 -4800 {
lab=cA7}
N 910 -4820 970 -4820 {
lab=cA8}
N 910 -4840 970 -4840 {
lab=cA9}
N 910 -4860 970 -4860 {
lab=cA10}
N 910 -4880 970 -4880 {
lab=cA11}
N 910 -4900 970 -4900 {
lab=cA12}
N 910 -4920 970 -4920 {
lab=cA13}
N 910 -4940 970 -4940 {
lab=cA14}
N 910 -4960 970 -4960 {
lab=cA15}
N 900 -4950 900 -4650 {bus=true
lab=cA[0..15]}
N 900 -4650 900 -4620 {bus=true
lab=cA[0..15]}
N 1270 -4660 1330 -4660 {
lab=cB0}
N 1270 -4680 1330 -4680 {
lab=cB1}
N 1270 -4700 1330 -4700 {
lab=cB2}
N 1270 -4720 1330 -4720 {
lab=cB3}
N 1270 -4740 1330 -4740 {
lab=cB4}
N 1270 -4760 1330 -4760 {
lab=cB5}
N 1270 -4780 1330 -4780 {
lab=cB6}
N 1270 -4800 1330 -4800 {
lab=cB7}
N 1270 -4820 1330 -4820 {
lab=cB8}
N 1270 -4840 1330 -4840 {
lab=cB9}
N 1270 -4860 1330 -4860 {
lab=cB10}
N 1270 -4880 1330 -4880 {
lab=cB11}
N 1270 -4900 1330 -4900 {
lab=cB12}
N 1270 -4920 1330 -4920 {
lab=cB13}
N 1270 -4940 1330 -4940 {
lab=cB14}
N 1270 -4960 1330 -4960 {
lab=cB15}
N 1340 -4950 1340 -4650 {bus=true
lab=cB[0..15]}
N 1340 -4650 1340 -4620 {bus=true
lab=cB[0..15]}
N 1610 -4650 1670 -4650 {
lab=cA0}
N 1610 -4670 1670 -4670 {
lab=cA1}
N 1610 -4690 1670 -4690 {
lab=cA2}
N 1610 -4710 1670 -4710 {
lab=cA3}
N 1610 -4730 1670 -4730 {
lab=cA4}
N 1610 -4750 1670 -4750 {
lab=cA5}
N 1610 -4770 1670 -4770 {
lab=cA6}
N 1610 -4790 1670 -4790 {
lab=cA7}
N 1610 -4810 1670 -4810 {
lab=cA8}
N 1610 -4830 1670 -4830 {
lab=cA9}
N 1610 -4850 1670 -4850 {
lab=cA10}
N 1610 -4870 1670 -4870 {
lab=cA11}
N 1610 -4890 1670 -4890 {
lab=cA12}
N 1610 -4910 1670 -4910 {
lab=cA13}
N 1610 -4930 1670 -4930 {
lab=cA14}
N 1610 -4950 1670 -4950 {
lab=cA15}
N 1600 -4940 1600 -4640 {bus=true
lab=cA[0..15]}
N 1600 -4640 1600 -4610 {bus=true
lab=cA[0..15]}
N 1970 -4650 2030 -4650 {
lab=cB0}
N 1970 -4670 2030 -4670 {
lab=cB1}
N 1970 -4690 2030 -4690 {
lab=cB2}
N 1970 -4710 2030 -4710 {
lab=cB3}
N 1970 -4730 2030 -4730 {
lab=cB4}
N 1970 -4750 2030 -4750 {
lab=cB5}
N 1970 -4770 2030 -4770 {
lab=cB6}
N 1970 -4790 2030 -4790 {
lab=cB7}
N 1970 -4810 2030 -4810 {
lab=cB8}
N 1970 -4830 2030 -4830 {
lab=cB9}
N 1970 -4850 2030 -4850 {
lab=cB10}
N 1970 -4870 2030 -4870 {
lab=cB11}
N 1970 -4890 2030 -4890 {
lab=cB12}
N 1970 -4910 2030 -4910 {
lab=cB13}
N 1970 -4930 2030 -4930 {
lab=cB14}
N 1970 -4950 2030 -4950 {
lab=cB15}
N 2040 -4940 2040 -4640 {bus=true
lab=cB[0..15]}
N 2040 -4640 2040 -4610 {bus=true
lab=cB[0..15]}
N 2340 -5340 2400 -5340 {
lab=rA0}
N 2750 -5340 2810 -5340 {
lab=rB0}
N 2750 -5360 2810 -5360 {
lab=rB1}
N 2750 -5380 2810 -5380 {
lab=rB2}
N 2750 -5400 2810 -5400 {
lab=rB3}
N 2750 -5420 2810 -5420 {
lab=rB4}
N 2750 -5440 2810 -5440 {
lab=rB5}
N 2750 -5460 2810 -5460 {
lab=rB6}
N 2750 -5480 2810 -5480 {
lab=rB7}
N 2750 -5500 2810 -5500 {
lab=rB8}
N 2750 -5520 2810 -5520 {
lab=rB9}
N 2750 -5540 2810 -5540 {
lab=rB10}
N 2750 -5560 2810 -5560 {
lab=rB11}
N 2750 -5580 2810 -5580 {
lab=rB12}
N 2750 -5600 2810 -5600 {
lab=rB13}
N 2750 -5620 2810 -5620 {
lab=rB14}
N 2750 -5640 2810 -5640 {
lab=rB15}
N 2190 -5340 2340 -5340 {
lab=rA0}
N 2190 -5380 2340 -5380 {
lab=rA2}
N 2190 -5400 2340 -5400 {
lab=rA3}
N 2190 -5420 2340 -5420 {
lab=rA4}
N 2190 -5440 2340 -5440 {
lab=rA5}
N 2190 -5460 2340 -5460 {
lab=rA6}
N 2190 -5480 2340 -5480 {
lab=rA7}
N 2190 -5500 2340 -5500 {
lab=rA8}
N 2190 -5540 2340 -5540 {
lab=rA10}
N 2190 -5520 2340 -5520 {
lab=rA9}
N 2190 -5560 2340 -5560 {
lab=rA11}
N 2190 -5580 2340 -5580 {
lab=rA12}
N 2190 -5600 2340 -5600 {
lab=rA13}
N 2190 -5620 2340 -5620 {
lab=rA14}
N 2190 -5640 2340 -5640 {
lab=rA15}
N 2190 -5360 2340 -5360 {
lab=rA1}
N 2340 -5360 2400 -5360 {
lab=rA1}
N 2340 -5380 2400 -5380 {
lab=rA2}
N 2340 -5400 2400 -5400 {
lab=rA3}
N 2340 -5420 2400 -5420 {
lab=rA4}
N 2340 -5440 2400 -5440 {
lab=rA5}
N 2340 -5460 2400 -5460 {
lab=rA6}
N 2340 -5480 2400 -5480 {
lab=rA7}
N 2340 -5500 2400 -5500 {
lab=rA8}
N 2340 -5520 2400 -5520 {
lab=rA9}
N 2340 -5540 2400 -5540 {
lab=rA10}
N 2340 -5560 2400 -5560 {
lab=rA11}
N 2340 -5580 2400 -5580 {
lab=rA12}
N 2340 -5600 2400 -5600 {
lab=rA13}
N 2340 -5620 2400 -5620 {
lab=rA14}
N 2340 -5640 2400 -5640 {
lab=rA15}
N 2180 -5630 2180 -5290 {
lab=rA[0..15]
bus=true}
N 2700 -5340 2750 -5340 {
lab=rB0}
N 2700 -5360 2750 -5360 {
lab=rB1}
N 2820 -5350 2820 -5290 {
lab=rB[0..15]
bus=true}
N 2700 -5380 2750 -5380 {
lab=rB2}
N 2700 -5400 2750 -5400 {
lab=rB3}
N 2700 -5420 2750 -5420 {
lab=rB4}
N 2700 -5440 2750 -5440 {
lab=rB5}
N 2700 -5460 2750 -5460 {
lab=rB6}
N 2700 -5480 2750 -5480 {
lab=rB7}
N 2700 -5500 2750 -5500 {
lab=rB8}
N 2700 -5520 2750 -5520 {
lab=rB9}
N 2700 -5540 2750 -5540 {
lab=rB10}
N 2700 -5560 2750 -5560 {
lab=rB11}
N 2700 -5580 2750 -5580 {
lab=rB12}
N 2700 -5600 2750 -5600 {
lab=rB13}
N 2700 -5620 2750 -5620 {
lab=rB14}
N 2700 -5640 2750 -5640 {
lab=rB15}
N 2820 -5630 2820 -5350 {
lab=rB[0..15]
bus=true}
N 2340 -4660 2400 -4660 {
lab=cA0}
N 2340 -4680 2400 -4680 {
lab=cA1}
N 2340 -4700 2400 -4700 {
lab=cA2}
N 2340 -4720 2400 -4720 {
lab=cA3}
N 2340 -4740 2400 -4740 {
lab=cA4}
N 2340 -4760 2400 -4760 {
lab=cA5}
N 2340 -4780 2400 -4780 {
lab=cA6}
N 2340 -4800 2400 -4800 {
lab=cA7}
N 2340 -4820 2400 -4820 {
lab=cA8}
N 2340 -4840 2400 -4840 {
lab=cA9}
N 2340 -4860 2400 -4860 {
lab=cA10}
N 2340 -4880 2400 -4880 {
lab=cA11}
N 2340 -4900 2400 -4900 {
lab=cA12}
N 2340 -4920 2400 -4920 {
lab=cA13}
N 2340 -4940 2400 -4940 {
lab=cA14}
N 2340 -4960 2400 -4960 {
lab=cA15}
N 2330 -4950 2330 -4650 {bus=true
lab=cA[0..15]}
N 2330 -4650 2330 -4620 {bus=true
lab=cA[0..15]}
N 2700 -4660 2760 -4660 {
lab=cB0}
N 2700 -4680 2760 -4680 {
lab=cB1}
N 2700 -4700 2760 -4700 {
lab=cB2}
N 2700 -4720 2760 -4720 {
lab=cB3}
N 2700 -4740 2760 -4740 {
lab=cB4}
N 2700 -4760 2760 -4760 {
lab=cB5}
N 2700 -4780 2760 -4780 {
lab=cB6}
N 2700 -4800 2760 -4800 {
lab=cB7}
N 2700 -4820 2760 -4820 {
lab=cB8}
N 2700 -4840 2760 -4840 {
lab=cB9}
N 2700 -4860 2760 -4860 {
lab=cB10}
N 2700 -4880 2760 -4880 {
lab=cB11}
N 2700 -4900 2760 -4900 {
lab=cB12}
N 2700 -4920 2760 -4920 {
lab=cB13}
N 2700 -4940 2760 -4940 {
lab=cB14}
N 2700 -4960 2760 -4960 {
lab=cB15}
N 2770 -4950 2770 -4650 {bus=true
lab=cB[0..15]}
N 2770 -4650 2770 -4620 {bus=true
lab=cB[0..15]}
N 3040 -5330 3100 -5330 {
lab=rA0}
N 3450 -5330 3510 -5330 {
lab=rB0}
N 3450 -5350 3510 -5350 {
lab=rB1}
N 3450 -5370 3510 -5370 {
lab=rB2}
N 3450 -5390 3510 -5390 {
lab=rB3}
N 3450 -5410 3510 -5410 {
lab=rB4}
N 3450 -5430 3510 -5430 {
lab=rB5}
N 3450 -5450 3510 -5450 {
lab=rB6}
N 3450 -5470 3510 -5470 {
lab=rB7}
N 3450 -5490 3510 -5490 {
lab=rB8}
N 3450 -5510 3510 -5510 {
lab=rB9}
N 3450 -5530 3510 -5530 {
lab=rB10}
N 3450 -5550 3510 -5550 {
lab=rB11}
N 3450 -5570 3510 -5570 {
lab=rB12}
N 3450 -5590 3510 -5590 {
lab=rB13}
N 3450 -5610 3510 -5610 {
lab=rB14}
N 3450 -5630 3510 -5630 {
lab=rB15}
N 2890 -5330 3040 -5330 {
lab=rA0}
N 2890 -5370 3040 -5370 {
lab=rA2}
N 2890 -5390 3040 -5390 {
lab=rA3}
N 2890 -5410 3040 -5410 {
lab=rA4}
N 2890 -5430 3040 -5430 {
lab=rA5}
N 2890 -5450 3040 -5450 {
lab=rA6}
N 2890 -5470 3040 -5470 {
lab=rA7}
N 2890 -5490 3040 -5490 {
lab=rA8}
N 2890 -5530 3040 -5530 {
lab=rA10}
N 2890 -5510 3040 -5510 {
lab=rA9}
N 2890 -5550 3040 -5550 {
lab=rA11}
N 2890 -5570 3040 -5570 {
lab=rA12}
N 2890 -5590 3040 -5590 {
lab=rA13}
N 2890 -5610 3040 -5610 {
lab=rA14}
N 2890 -5630 3040 -5630 {
lab=rA15}
N 2890 -5350 3040 -5350 {
lab=rA1}
N 3040 -5350 3100 -5350 {
lab=rA1}
N 3040 -5370 3100 -5370 {
lab=rA2}
N 3040 -5390 3100 -5390 {
lab=rA3}
N 3040 -5410 3100 -5410 {
lab=rA4}
N 3040 -5430 3100 -5430 {
lab=rA5}
N 3040 -5450 3100 -5450 {
lab=rA6}
N 3040 -5470 3100 -5470 {
lab=rA7}
N 3040 -5490 3100 -5490 {
lab=rA8}
N 3040 -5510 3100 -5510 {
lab=rA9}
N 3040 -5530 3100 -5530 {
lab=rA10}
N 3040 -5550 3100 -5550 {
lab=rA11}
N 3040 -5570 3100 -5570 {
lab=rA12}
N 3040 -5590 3100 -5590 {
lab=rA13}
N 3040 -5610 3100 -5610 {
lab=rA14}
N 3040 -5630 3100 -5630 {
lab=rA15}
N 2880 -5620 2880 -5280 {
lab=rA[0..15]
bus=true}
N 3400 -5330 3450 -5330 {
lab=rB0}
N 3400 -5350 3450 -5350 {
lab=rB1}
N 3520 -5340 3520 -5280 {
lab=rB[0..15]
bus=true}
N 3400 -5370 3450 -5370 {
lab=rB2}
N 3400 -5390 3450 -5390 {
lab=rB3}
N 3400 -5410 3450 -5410 {
lab=rB4}
N 3400 -5430 3450 -5430 {
lab=rB5}
N 3400 -5450 3450 -5450 {
lab=rB6}
N 3400 -5470 3450 -5470 {
lab=rB7}
N 3400 -5490 3450 -5490 {
lab=rB8}
N 3400 -5510 3450 -5510 {
lab=rB9}
N 3400 -5530 3450 -5530 {
lab=rB10}
N 3400 -5550 3450 -5550 {
lab=rB11}
N 3400 -5570 3450 -5570 {
lab=rB12}
N 3400 -5590 3450 -5590 {
lab=rB13}
N 3400 -5610 3450 -5610 {
lab=rB14}
N 3400 -5630 3450 -5630 {
lab=rB15}
N 3520 -5620 3520 -5340 {
lab=rB[0..15]
bus=true}
N 3040 -4650 3100 -4650 {
lab=cA0}
N 3040 -4670 3100 -4670 {
lab=cA1}
N 3040 -4690 3100 -4690 {
lab=cA2}
N 3040 -4710 3100 -4710 {
lab=cA3}
N 3040 -4730 3100 -4730 {
lab=cA4}
N 3040 -4750 3100 -4750 {
lab=cA5}
N 3040 -4770 3100 -4770 {
lab=cA6}
N 3040 -4790 3100 -4790 {
lab=cA7}
N 3040 -4810 3100 -4810 {
lab=cA8}
N 3040 -4830 3100 -4830 {
lab=cA9}
N 3040 -4850 3100 -4850 {
lab=cA10}
N 3040 -4870 3100 -4870 {
lab=cA11}
N 3040 -4890 3100 -4890 {
lab=cA12}
N 3040 -4910 3100 -4910 {
lab=cA13}
N 3040 -4930 3100 -4930 {
lab=cA14}
N 3040 -4950 3100 -4950 {
lab=cA15}
N 3030 -4940 3030 -4640 {bus=true
lab=cA[0..15]}
N 3030 -4640 3030 -4610 {bus=true
lab=cA[0..15]}
N 3400 -4650 3460 -4650 {
lab=cB0}
N 3400 -4670 3460 -4670 {
lab=cB1}
N 3400 -4690 3460 -4690 {
lab=cB2}
N 3400 -4710 3460 -4710 {
lab=cB3}
N 3400 -4730 3460 -4730 {
lab=cB4}
N 3400 -4750 3460 -4750 {
lab=cB5}
N 3400 -4770 3460 -4770 {
lab=cB6}
N 3400 -4790 3460 -4790 {
lab=cB7}
N 3400 -4810 3460 -4810 {
lab=cB8}
N 3400 -4830 3460 -4830 {
lab=cB9}
N 3400 -4850 3460 -4850 {
lab=cB10}
N 3400 -4870 3460 -4870 {
lab=cB11}
N 3400 -4890 3460 -4890 {
lab=cB12}
N 3400 -4910 3460 -4910 {
lab=cB13}
N 3400 -4930 3460 -4930 {
lab=cB14}
N 3400 -4950 3460 -4950 {
lab=cB15}
N 3470 -4940 3470 -4640 {bus=true
lab=cB[0..15]}
N 3470 -4640 3470 -4610 {bus=true
lab=cB[0..15]}
N 3750 -5330 3810 -5330 {
lab=rA0}
N 4160 -5330 4220 -5330 {
lab=rB0}
N 4160 -5350 4220 -5350 {
lab=rB1}
N 4160 -5370 4220 -5370 {
lab=rB2}
N 4160 -5390 4220 -5390 {
lab=rB3}
N 4160 -5410 4220 -5410 {
lab=rB4}
N 4160 -5430 4220 -5430 {
lab=rB5}
N 4160 -5450 4220 -5450 {
lab=rB6}
N 4160 -5470 4220 -5470 {
lab=rB7}
N 4160 -5490 4220 -5490 {
lab=rB8}
N 4160 -5510 4220 -5510 {
lab=rB9}
N 4160 -5530 4220 -5530 {
lab=rB10}
N 4160 -5550 4220 -5550 {
lab=rB11}
N 4160 -5570 4220 -5570 {
lab=rB12}
N 4160 -5590 4220 -5590 {
lab=rB13}
N 4160 -5610 4220 -5610 {
lab=rB14}
N 4160 -5630 4220 -5630 {
lab=rB15}
N 3600 -5330 3750 -5330 {
lab=rA0}
N 3600 -5370 3750 -5370 {
lab=rA2}
N 3600 -5390 3750 -5390 {
lab=rA3}
N 3600 -5410 3750 -5410 {
lab=rA4}
N 3600 -5430 3750 -5430 {
lab=rA5}
N 3600 -5450 3750 -5450 {
lab=rA6}
N 3600 -5470 3750 -5470 {
lab=rA7}
N 3600 -5490 3750 -5490 {
lab=rA8}
N 3600 -5530 3750 -5530 {
lab=rA10}
N 3600 -5510 3750 -5510 {
lab=rA9}
N 3600 -5550 3750 -5550 {
lab=rA11}
N 3600 -5570 3750 -5570 {
lab=rA12}
N 3600 -5590 3750 -5590 {
lab=rA13}
N 3600 -5610 3750 -5610 {
lab=rA14}
N 3600 -5630 3750 -5630 {
lab=rA15}
N 3600 -5350 3750 -5350 {
lab=rA1}
N 3750 -5350 3810 -5350 {
lab=rA1}
N 3750 -5370 3810 -5370 {
lab=rA2}
N 3750 -5390 3810 -5390 {
lab=rA3}
N 3750 -5410 3810 -5410 {
lab=rA4}
N 3750 -5430 3810 -5430 {
lab=rA5}
N 3750 -5450 3810 -5450 {
lab=rA6}
N 3750 -5470 3810 -5470 {
lab=rA7}
N 3750 -5490 3810 -5490 {
lab=rA8}
N 3750 -5510 3810 -5510 {
lab=rA9}
N 3750 -5530 3810 -5530 {
lab=rA10}
N 3750 -5550 3810 -5550 {
lab=rA11}
N 3750 -5570 3810 -5570 {
lab=rA12}
N 3750 -5590 3810 -5590 {
lab=rA13}
N 3750 -5610 3810 -5610 {
lab=rA14}
N 3750 -5630 3810 -5630 {
lab=rA15}
N 3590 -5620 3590 -5280 {
lab=rA[0..15]
bus=true}
N 4110 -5330 4160 -5330 {
lab=rB0}
N 4110 -5350 4160 -5350 {
lab=rB1}
N 4230 -5340 4230 -5280 {
lab=rB[0..15]
bus=true}
N 4110 -5370 4160 -5370 {
lab=rB2}
N 4110 -5390 4160 -5390 {
lab=rB3}
N 4110 -5410 4160 -5410 {
lab=rB4}
N 4110 -5430 4160 -5430 {
lab=rB5}
N 4110 -5450 4160 -5450 {
lab=rB6}
N 4110 -5470 4160 -5470 {
lab=rB7}
N 4110 -5490 4160 -5490 {
lab=rB8}
N 4110 -5510 4160 -5510 {
lab=rB9}
N 4110 -5530 4160 -5530 {
lab=rB10}
N 4110 -5550 4160 -5550 {
lab=rB11}
N 4110 -5570 4160 -5570 {
lab=rB12}
N 4110 -5590 4160 -5590 {
lab=rB13}
N 4110 -5610 4160 -5610 {
lab=rB14}
N 4110 -5630 4160 -5630 {
lab=rB15}
N 4230 -5620 4230 -5340 {
lab=rB[0..15]
bus=true}
N 3750 -4650 3810 -4650 {
lab=cA0}
N 3750 -4670 3810 -4670 {
lab=cA1}
N 3750 -4690 3810 -4690 {
lab=cA2}
N 3750 -4710 3810 -4710 {
lab=cA3}
N 3750 -4730 3810 -4730 {
lab=cA4}
N 3750 -4750 3810 -4750 {
lab=cA5}
N 3750 -4770 3810 -4770 {
lab=cA6}
N 3750 -4790 3810 -4790 {
lab=cA7}
N 3750 -4810 3810 -4810 {
lab=cA8}
N 3750 -4830 3810 -4830 {
lab=cA9}
N 3750 -4850 3810 -4850 {
lab=cA10}
N 3750 -4870 3810 -4870 {
lab=cA11}
N 3750 -4890 3810 -4890 {
lab=cA12}
N 3750 -4910 3810 -4910 {
lab=cA13}
N 3750 -4930 3810 -4930 {
lab=cA14}
N 3750 -4950 3810 -4950 {
lab=cA15}
N 3740 -4940 3740 -4640 {bus=true
lab=cA[0..15]}
N 3740 -4640 3740 -4610 {bus=true
lab=cA[0..15]}
N 4110 -4650 4170 -4650 {
lab=cB0}
N 4110 -4670 4170 -4670 {
lab=cB1}
N 4110 -4690 4170 -4690 {
lab=cB2}
N 4110 -4710 4170 -4710 {
lab=cB3}
N 4110 -4730 4170 -4730 {
lab=cB4}
N 4110 -4750 4170 -4750 {
lab=cB5}
N 4110 -4770 4170 -4770 {
lab=cB6}
N 4110 -4790 4170 -4790 {
lab=cB7}
N 4110 -4810 4170 -4810 {
lab=cB8}
N 4110 -4830 4170 -4830 {
lab=cB9}
N 4110 -4850 4170 -4850 {
lab=cB10}
N 4110 -4870 4170 -4870 {
lab=cB11}
N 4110 -4890 4170 -4890 {
lab=cB12}
N 4110 -4910 4170 -4910 {
lab=cB13}
N 4110 -4930 4170 -4930 {
lab=cB14}
N 4110 -4950 4170 -4950 {
lab=cB15}
N 4180 -4940 4180 -4640 {bus=true
lab=cB[0..15]}
N 4180 -4640 4180 -4610 {bus=true
lab=cB[0..15]}
N 2340 -5920 2400 -5920 {
lab=col3_sel}
N 2340 -5940 2400 -5940 {
lab=row2_sel}
N 2340 -5700 2400 -5700 {
lab=Vcplus}
N 2340 -5720 2400 -5720 {
lab=Vcminus}
N 2340 -5740 2400 -5740 {
lab=Vref}
N 2340 -5760 2400 -5760 {
lab=Vref_comp}
N 2340 -5780 2400 -5780 {
lab=RISC_CLK}
N 2340 -5840 2400 -5840 {
lab=SAMPLE}
N 2340 -5820 2400 -5820 {
lab=Vrminus}
N 2340 -5800 2400 -5800 {
lab=Vrplus}
N 2340 -5880 2400 -5880 {
lab=WR}
N 2340 -5900 2400 -5900 {
lab=Vgnr}
N 2340 -5860 2400 -5860 {
lab=Vgpr}
N 3040 -5910 3100 -5910 {
lab=col4_sel}
N 3040 -5930 3100 -5930 {
lab=row2_sel}
N 3040 -5690 3100 -5690 {
lab=Vcplus}
N 3040 -5710 3100 -5710 {
lab=Vcminus}
N 3040 -5730 3100 -5730 {
lab=Vref}
N 3040 -5750 3100 -5750 {
lab=Vref_comp}
N 3040 -5770 3100 -5770 {
lab=RISC_CLK}
N 3040 -5830 3100 -5830 {
lab=SAMPLE}
N 3040 -5810 3100 -5810 {
lab=Vrminus}
N 3040 -5790 3100 -5790 {
lab=Vrplus}
N 3040 -5870 3100 -5870 {
lab=WR}
N 3040 -5890 3100 -5890 {
lab=Vgnr}
N 3040 -5850 3100 -5850 {
lab=Vgpr}
N 3750 -5910 3810 -5910 {
lab=col5_sel}
N 3750 -5930 3810 -5930 {
lab=row2_sel}
N 3750 -5690 3810 -5690 {
lab=Vcplus}
N 3750 -5710 3810 -5710 {
lab=Vcminus}
N 3750 -5730 3810 -5730 {
lab=Vref}
N 3750 -5750 3810 -5750 {
lab=Vref_comp}
N 3750 -5770 3810 -5770 {
lab=RISC_CLK}
N 3750 -5830 3810 -5830 {
lab=SAMPLE}
N 3750 -5810 3810 -5810 {
lab=Vrminus}
N 3750 -5790 3810 -5790 {
lab=Vrplus}
N 3750 -5870 3810 -5870 {
lab=WR}
N 3750 -5890 3810 -5890 {
lab=Vgnr}
N 3750 -5850 3810 -5850 {
lab=Vgpr}
N 190 -7360 250 -7360 {
lab=rA0}
N 600 -7360 660 -7360 {
lab=rB0}
N 600 -7380 660 -7380 {
lab=rB1}
N 600 -7400 660 -7400 {
lab=rB2}
N 600 -7420 660 -7420 {
lab=rB3}
N 600 -7440 660 -7440 {
lab=rB4}
N 600 -7460 660 -7460 {
lab=rB5}
N 600 -7480 660 -7480 {
lab=rB6}
N 600 -7500 660 -7500 {
lab=rB7}
N 600 -7520 660 -7520 {
lab=rB8}
N 600 -7540 660 -7540 {
lab=rB9}
N 600 -7560 660 -7560 {
lab=rB10}
N 600 -7580 660 -7580 {
lab=rB11}
N 600 -7600 660 -7600 {
lab=rB12}
N 600 -7620 660 -7620 {
lab=rB13}
N 600 -7640 660 -7640 {
lab=rB14}
N 600 -7660 660 -7660 {
lab=rB15}
N 190 -7020 250 -7020 {
lab=WL0}
N 190 -7040 250 -7040 {
lab=WL1}
N 190 -7060 250 -7060 {
lab=WL2}
N 190 -7080 250 -7080 {
lab=WL3}
N 190 -7100 250 -7100 {
lab=WL4}
N 190 -7120 250 -7120 {
lab=WL5}
N 190 -7140 250 -7140 {
lab=WL6}
N 190 -7160 250 -7160 {
lab=WL7}
N 190 -7180 250 -7180 {
lab=WL8}
N 190 -7200 250 -7200 {
lab=WL9}
N 190 -7220 250 -7220 {
lab=WL10}
N 190 -7240 250 -7240 {
lab=WL11}
N 190 -7260 250 -7260 {
lab=WL12}
N 190 -7280 250 -7280 {
lab=WL13}
N 190 -7300 250 -7300 {
lab=WL14}
N 190 -7320 250 -7320 {
lab=WL15}
N 190 -6680 250 -6680 {
lab=cA0}
N 190 -6700 250 -6700 {
lab=cA1}
N 190 -6720 250 -6720 {
lab=cA2}
N 190 -6740 250 -6740 {
lab=cA3}
N 190 -6760 250 -6760 {
lab=cA4}
N 190 -6780 250 -6780 {
lab=cA5}
N 190 -6800 250 -6800 {
lab=cA6}
N 190 -6820 250 -6820 {
lab=cA7}
N 190 -6840 250 -6840 {
lab=cA8}
N 190 -6860 250 -6860 {
lab=cA9}
N 190 -6880 250 -6880 {
lab=cA10}
N 190 -6900 250 -6900 {
lab=cA11}
N 190 -6920 250 -6920 {
lab=cA12}
N 190 -6940 250 -6940 {
lab=cA13}
N 190 -6960 250 -6960 {
lab=cA14}
N 190 -6980 250 -6980 {
lab=cA15}
N 190 -7940 250 -7940 {
lab=col0_sel}
N 190 -7960 250 -7960 {
lab=row3_sel}
N 190 -7900 250 -7900 {
lab=WR}
N 190 -7920 250 -7920 {
lab=Vgnr}
N 190 -7880 250 -7880 {
lab=Vgpr}
N 190 -7720 250 -7720 {
lab=Vcplus}
N 190 -7740 250 -7740 {
lab=Vcminus}
N 190 -7760 250 -7760 {
lab=Vref}
N 190 -7780 250 -7780 {
lab=Vref_comp}
N 190 -7800 250 -7800 {
lab=RISC_CLK}
N 550 -7900 610 -7900 {
lab=vssd1}
N 550 -7920 610 -7920 {
lab=vdda1}
N 550 -7940 610 -7940 {
lab=vccd1}
N 550 -7960 610 -7960 {
lab=latch_high0}
N 1970 -7950 2030 -7950 {
lab=latch_high2}
N 2700 -7900 2760 -7900 {
lab=vssd1}
N 2700 -7920 2760 -7920 {
lab=vdda1}
N 2700 -7940 2760 -7940 {
lab=vccd1}
N 2700 -7960 2760 -7960 {
lab=latch_high3}
N 3400 -7890 3460 -7890 {
lab=vssd1}
N 3400 -7910 3460 -7910 {
lab=vdda1}
N 3400 -7930 3460 -7930 {
lab=vccd1}
N 3400 -7950 3460 -7950 {
lab=latch_high4}
N 4110 -7890 4170 -7890 {
lab=vssd1}
N 4110 -7910 4170 -7910 {
lab=vdda1}
N 4110 -7930 4170 -7930 {
lab=vccd1}
N 4110 -7950 4170 -7950 {
lab=latch_high5}
N 130 -7020 190 -7020 {
lab=WL0}
N 130 -7040 190 -7040 {
lab=WL1}
N 130 -7060 190 -7060 {
lab=WL2}
N 130 -7080 190 -7080 {
lab=WL3}
N 130 -7100 190 -7100 {
lab=WL4}
N 130 -7120 190 -7120 {
lab=WL5}
N 130 -7140 190 -7140 {
lab=WL6}
N 130 -7160 190 -7160 {
lab=WL7}
N 130 -7180 190 -7180 {
lab=WL8}
N 130 -7200 190 -7200 {
lab=WL9}
N 130 -7220 190 -7220 {
lab=WL10}
N 130 -7240 190 -7240 {
lab=WL11}
N 130 -7260 190 -7260 {
lab=WL12}
N 130 -7280 190 -7280 {
lab=WL13}
N 130 -7300 190 -7300 {
lab=WL14}
N 130 -7320 190 -7320 {
lab=WL15}
N 70 -7020 130 -7020 {
lab=WL0}
N 70 -7040 130 -7040 {
lab=WL1}
N 70 -7060 130 -7060 {
lab=WL2}
N 70 -7080 130 -7080 {
lab=WL3}
N 70 -7100 130 -7100 {
lab=WL4}
N 70 -7120 130 -7120 {
lab=WL5}
N 70 -7140 130 -7140 {
lab=WL6}
N 70 -7160 130 -7160 {
lab=WL7}
N 70 -7180 130 -7180 {
lab=WL8}
N 70 -7200 130 -7200 {
lab=WL9}
N 70 -7220 130 -7220 {
lab=WL10}
N 70 -7240 130 -7240 {
lab=WL11}
N 70 -7260 130 -7260 {
lab=WL12}
N 70 -7280 130 -7280 {
lab=WL13}
N 70 -7300 130 -7300 {
lab=WL14}
N 70 -7320 130 -7320 {
lab=WL15}
N 60 -7310 60 -7010 {bus=true
lab=WL[0..15]}
N 60 -7010 60 -6980 {bus=true
lab=WL[0..15]}
N 910 -7020 970 -7020 {
lab=WL0}
N 910 -7040 970 -7040 {
lab=WL1}
N 910 -7060 970 -7060 {
lab=WL2}
N 910 -7080 970 -7080 {
lab=WL3}
N 910 -7100 970 -7100 {
lab=WL4}
N 910 -7120 970 -7120 {
lab=WL5}
N 910 -7140 970 -7140 {
lab=WL6}
N 910 -7160 970 -7160 {
lab=WL7}
N 910 -7180 970 -7180 {
lab=WL8}
N 910 -7200 970 -7200 {
lab=WL9}
N 910 -7220 970 -7220 {
lab=WL10}
N 910 -7240 970 -7240 {
lab=WL11}
N 910 -7260 970 -7260 {
lab=WL12}
N 910 -7280 970 -7280 {
lab=WL13}
N 910 -7300 970 -7300 {
lab=WL14}
N 910 -7320 970 -7320 {
lab=WL15}
N 850 -7020 910 -7020 {
lab=WL0}
N 850 -7040 910 -7040 {
lab=WL1}
N 850 -7060 910 -7060 {
lab=WL2}
N 850 -7080 910 -7080 {
lab=WL3}
N 850 -7100 910 -7100 {
lab=WL4}
N 850 -7120 910 -7120 {
lab=WL5}
N 850 -7140 910 -7140 {
lab=WL6}
N 850 -7160 910 -7160 {
lab=WL7}
N 850 -7180 910 -7180 {
lab=WL8}
N 850 -7200 910 -7200 {
lab=WL9}
N 850 -7220 910 -7220 {
lab=WL10}
N 850 -7240 910 -7240 {
lab=WL11}
N 850 -7260 910 -7260 {
lab=WL12}
N 850 -7280 910 -7280 {
lab=WL13}
N 850 -7300 910 -7300 {
lab=WL14}
N 850 -7320 910 -7320 {
lab=WL15}
N 790 -7020 850 -7020 {
lab=WL0}
N 790 -7040 850 -7040 {
lab=WL1}
N 790 -7060 850 -7060 {
lab=WL2}
N 790 -7080 850 -7080 {
lab=WL3}
N 790 -7100 850 -7100 {
lab=WL4}
N 790 -7120 850 -7120 {
lab=WL5}
N 790 -7140 850 -7140 {
lab=WL6}
N 790 -7160 850 -7160 {
lab=WL7}
N 790 -7180 850 -7180 {
lab=WL8}
N 790 -7200 850 -7200 {
lab=WL9}
N 790 -7220 850 -7220 {
lab=WL10}
N 790 -7240 850 -7240 {
lab=WL11}
N 790 -7260 850 -7260 {
lab=WL12}
N 790 -7280 850 -7280 {
lab=WL13}
N 790 -7300 850 -7300 {
lab=WL14}
N 790 -7320 850 -7320 {
lab=WL15}
N 780 -7310 780 -7010 {bus=true
lab=WL[0..15]}
N 780 -7010 780 -6980 {bus=true
lab=WL[0..15]}
N 1610 -7010 1670 -7010 {
lab=WL0}
N 1610 -7030 1670 -7030 {
lab=WL1}
N 1610 -7050 1670 -7050 {
lab=WL2}
N 1610 -7070 1670 -7070 {
lab=WL3}
N 1610 -7090 1670 -7090 {
lab=WL4}
N 1610 -7110 1670 -7110 {
lab=WL5}
N 1610 -7130 1670 -7130 {
lab=WL6}
N 1610 -7150 1670 -7150 {
lab=WL7}
N 1610 -7170 1670 -7170 {
lab=WL8}
N 1610 -7190 1670 -7190 {
lab=WL9}
N 1610 -7210 1670 -7210 {
lab=WL10}
N 1610 -7230 1670 -7230 {
lab=WL11}
N 1610 -7250 1670 -7250 {
lab=WL12}
N 1610 -7270 1670 -7270 {
lab=WL13}
N 1610 -7290 1670 -7290 {
lab=WL14}
N 1610 -7310 1670 -7310 {
lab=WL15}
N 1550 -7010 1610 -7010 {
lab=WL0}
N 1550 -7030 1610 -7030 {
lab=WL1}
N 1550 -7050 1610 -7050 {
lab=WL2}
N 1550 -7070 1610 -7070 {
lab=WL3}
N 1550 -7090 1610 -7090 {
lab=WL4}
N 1550 -7110 1610 -7110 {
lab=WL5}
N 1550 -7130 1610 -7130 {
lab=WL6}
N 1550 -7150 1610 -7150 {
lab=WL7}
N 1550 -7170 1610 -7170 {
lab=WL8}
N 1550 -7190 1610 -7190 {
lab=WL9}
N 1550 -7210 1610 -7210 {
lab=WL10}
N 1550 -7230 1610 -7230 {
lab=WL11}
N 1550 -7250 1610 -7250 {
lab=WL12}
N 1550 -7270 1610 -7270 {
lab=WL13}
N 1550 -7290 1610 -7290 {
lab=WL14}
N 1550 -7310 1610 -7310 {
lab=WL15}
N 1490 -7010 1550 -7010 {
lab=WL0}
N 1490 -7030 1550 -7030 {
lab=WL1}
N 1490 -7050 1550 -7050 {
lab=WL2}
N 1490 -7070 1550 -7070 {
lab=WL3}
N 1490 -7090 1550 -7090 {
lab=WL4}
N 1490 -7110 1550 -7110 {
lab=WL5}
N 1490 -7130 1550 -7130 {
lab=WL6}
N 1490 -7150 1550 -7150 {
lab=WL7}
N 1490 -7170 1550 -7170 {
lab=WL8}
N 1490 -7190 1550 -7190 {
lab=WL9}
N 1490 -7210 1550 -7210 {
lab=WL10}
N 1490 -7230 1550 -7230 {
lab=WL11}
N 1490 -7250 1550 -7250 {
lab=WL12}
N 1490 -7270 1550 -7270 {
lab=WL13}
N 1490 -7290 1550 -7290 {
lab=WL14}
N 1490 -7310 1550 -7310 {
lab=WL15}
N 1480 -7300 1480 -7000 {bus=true
lab=WL[0..15]}
N 1480 -7000 1480 -6970 {bus=true
lab=WL[0..15]}
N 2340 -7020 2400 -7020 {
lab=WL0}
N 2340 -7040 2400 -7040 {
lab=WL1}
N 2340 -7060 2400 -7060 {
lab=WL2}
N 2340 -7080 2400 -7080 {
lab=WL3}
N 2340 -7100 2400 -7100 {
lab=WL4}
N 2340 -7120 2400 -7120 {
lab=WL5}
N 2340 -7140 2400 -7140 {
lab=WL6}
N 2340 -7160 2400 -7160 {
lab=WL7}
N 2340 -7180 2400 -7180 {
lab=WL8}
N 2340 -7200 2400 -7200 {
lab=WL9}
N 2340 -7220 2400 -7220 {
lab=WL10}
N 2340 -7240 2400 -7240 {
lab=WL11}
N 2340 -7260 2400 -7260 {
lab=WL12}
N 2340 -7280 2400 -7280 {
lab=WL13}
N 2340 -7300 2400 -7300 {
lab=WL14}
N 2340 -7320 2400 -7320 {
lab=WL15}
N 2280 -7020 2340 -7020 {
lab=WL0}
N 2280 -7040 2340 -7040 {
lab=WL1}
N 2280 -7060 2340 -7060 {
lab=WL2}
N 2280 -7080 2340 -7080 {
lab=WL3}
N 2280 -7100 2340 -7100 {
lab=WL4}
N 2280 -7120 2340 -7120 {
lab=WL5}
N 2280 -7140 2340 -7140 {
lab=WL6}
N 2280 -7160 2340 -7160 {
lab=WL7}
N 2280 -7180 2340 -7180 {
lab=WL8}
N 2280 -7200 2340 -7200 {
lab=WL9}
N 2280 -7220 2340 -7220 {
lab=WL10}
N 2280 -7240 2340 -7240 {
lab=WL11}
N 2280 -7260 2340 -7260 {
lab=WL12}
N 2280 -7280 2340 -7280 {
lab=WL13}
N 2280 -7300 2340 -7300 {
lab=WL14}
N 2280 -7320 2340 -7320 {
lab=WL15}
N 2220 -7020 2280 -7020 {
lab=WL0}
N 2220 -7040 2280 -7040 {
lab=WL1}
N 2220 -7060 2280 -7060 {
lab=WL2}
N 2220 -7080 2280 -7080 {
lab=WL3}
N 2220 -7100 2280 -7100 {
lab=WL4}
N 2220 -7120 2280 -7120 {
lab=WL5}
N 2220 -7140 2280 -7140 {
lab=WL6}
N 2220 -7160 2280 -7160 {
lab=WL7}
N 2220 -7180 2280 -7180 {
lab=WL8}
N 2220 -7200 2280 -7200 {
lab=WL9}
N 2220 -7220 2280 -7220 {
lab=WL10}
N 2220 -7240 2280 -7240 {
lab=WL11}
N 2220 -7260 2280 -7260 {
lab=WL12}
N 2220 -7280 2280 -7280 {
lab=WL13}
N 2220 -7300 2280 -7300 {
lab=WL14}
N 2220 -7320 2280 -7320 {
lab=WL15}
N 2210 -7310 2210 -7010 {bus=true
lab=WL[0..15]}
N 2210 -7010 2210 -6980 {bus=true
lab=WL[0..15]}
N 3040 -7010 3100 -7010 {
lab=WL0}
N 3040 -7030 3100 -7030 {
lab=WL1}
N 3040 -7050 3100 -7050 {
lab=WL2}
N 3040 -7070 3100 -7070 {
lab=WL3}
N 3040 -7090 3100 -7090 {
lab=WL4}
N 3040 -7110 3100 -7110 {
lab=WL5}
N 3040 -7130 3100 -7130 {
lab=WL6}
N 3040 -7150 3100 -7150 {
lab=WL7}
N 3040 -7170 3100 -7170 {
lab=WL8}
N 3040 -7190 3100 -7190 {
lab=WL9}
N 3040 -7210 3100 -7210 {
lab=WL10}
N 3040 -7230 3100 -7230 {
lab=WL11}
N 3040 -7250 3100 -7250 {
lab=WL12}
N 3040 -7270 3100 -7270 {
lab=WL13}
N 3040 -7290 3100 -7290 {
lab=WL14}
N 3040 -7310 3100 -7310 {
lab=WL15}
N 2980 -7010 3040 -7010 {
lab=WL0}
N 2980 -7030 3040 -7030 {
lab=WL1}
N 2980 -7050 3040 -7050 {
lab=WL2}
N 2980 -7070 3040 -7070 {
lab=WL3}
N 2980 -7090 3040 -7090 {
lab=WL4}
N 2980 -7110 3040 -7110 {
lab=WL5}
N 2980 -7130 3040 -7130 {
lab=WL6}
N 2980 -7150 3040 -7150 {
lab=WL7}
N 2980 -7170 3040 -7170 {
lab=WL8}
N 2980 -7190 3040 -7190 {
lab=WL9}
N 2980 -7210 3040 -7210 {
lab=WL10}
N 2980 -7230 3040 -7230 {
lab=WL11}
N 2980 -7250 3040 -7250 {
lab=WL12}
N 2980 -7270 3040 -7270 {
lab=WL13}
N 2980 -7290 3040 -7290 {
lab=WL14}
N 2980 -7310 3040 -7310 {
lab=WL15}
N 2920 -7010 2980 -7010 {
lab=WL0}
N 2920 -7030 2980 -7030 {
lab=WL1}
N 2920 -7050 2980 -7050 {
lab=WL2}
N 2920 -7070 2980 -7070 {
lab=WL3}
N 2920 -7090 2980 -7090 {
lab=WL4}
N 2920 -7110 2980 -7110 {
lab=WL5}
N 2920 -7130 2980 -7130 {
lab=WL6}
N 2920 -7150 2980 -7150 {
lab=WL7}
N 2920 -7170 2980 -7170 {
lab=WL8}
N 2920 -7190 2980 -7190 {
lab=WL9}
N 2920 -7210 2980 -7210 {
lab=WL10}
N 2920 -7230 2980 -7230 {
lab=WL11}
N 2920 -7250 2980 -7250 {
lab=WL12}
N 2920 -7270 2980 -7270 {
lab=WL13}
N 2920 -7290 2980 -7290 {
lab=WL14}
N 2920 -7310 2980 -7310 {
lab=WL15}
N 2910 -7300 2910 -7000 {bus=true
lab=WL[0..15]}
N 2910 -7000 2910 -6970 {bus=true
lab=WL[0..15]}
N 3750 -7010 3810 -7010 {
lab=WL0}
N 3750 -7030 3810 -7030 {
lab=WL1}
N 3750 -7050 3810 -7050 {
lab=WL2}
N 3750 -7070 3810 -7070 {
lab=WL3}
N 3750 -7090 3810 -7090 {
lab=WL4}
N 3750 -7110 3810 -7110 {
lab=WL5}
N 3750 -7130 3810 -7130 {
lab=WL6}
N 3750 -7150 3810 -7150 {
lab=WL7}
N 3750 -7170 3810 -7170 {
lab=WL8}
N 3750 -7190 3810 -7190 {
lab=WL9}
N 3750 -7210 3810 -7210 {
lab=WL10}
N 3750 -7230 3810 -7230 {
lab=WL11}
N 3750 -7250 3810 -7250 {
lab=WL12}
N 3750 -7270 3810 -7270 {
lab=WL13}
N 3750 -7290 3810 -7290 {
lab=WL14}
N 3750 -7310 3810 -7310 {
lab=WL15}
N 3690 -7010 3750 -7010 {
lab=WL0}
N 3690 -7030 3750 -7030 {
lab=WL1}
N 3690 -7050 3750 -7050 {
lab=WL2}
N 3690 -7070 3750 -7070 {
lab=WL3}
N 3690 -7090 3750 -7090 {
lab=WL4}
N 3690 -7110 3750 -7110 {
lab=WL5}
N 3690 -7130 3750 -7130 {
lab=WL6}
N 3690 -7150 3750 -7150 {
lab=WL7}
N 3690 -7170 3750 -7170 {
lab=WL8}
N 3690 -7190 3750 -7190 {
lab=WL9}
N 3690 -7210 3750 -7210 {
lab=WL10}
N 3690 -7230 3750 -7230 {
lab=WL11}
N 3690 -7250 3750 -7250 {
lab=WL12}
N 3690 -7270 3750 -7270 {
lab=WL13}
N 3690 -7290 3750 -7290 {
lab=WL14}
N 3690 -7310 3750 -7310 {
lab=WL15}
N 3630 -7010 3690 -7010 {
lab=WL0}
N 3630 -7030 3690 -7030 {
lab=WL1}
N 3630 -7050 3690 -7050 {
lab=WL2}
N 3630 -7070 3690 -7070 {
lab=WL3}
N 3630 -7090 3690 -7090 {
lab=WL4}
N 3630 -7110 3690 -7110 {
lab=WL5}
N 3630 -7130 3690 -7130 {
lab=WL6}
N 3630 -7150 3690 -7150 {
lab=WL7}
N 3630 -7170 3690 -7170 {
lab=WL8}
N 3630 -7190 3690 -7190 {
lab=WL9}
N 3630 -7210 3690 -7210 {
lab=WL10}
N 3630 -7230 3690 -7230 {
lab=WL11}
N 3630 -7250 3690 -7250 {
lab=WL12}
N 3630 -7270 3690 -7270 {
lab=WL13}
N 3630 -7290 3690 -7290 {
lab=WL14}
N 3630 -7310 3690 -7310 {
lab=WL15}
N 3620 -7300 3620 -7000 {bus=true
lab=WL[0..15]}
N 3620 -7000 3620 -6970 {bus=true
lab=WL[0..15]}
N 40 -7360 190 -7360 {
lab=rA0}
N 40 -7400 190 -7400 {
lab=rA2}
N 40 -7420 190 -7420 {
lab=rA3}
N 40 -7440 190 -7440 {
lab=rA4}
N 40 -7460 190 -7460 {
lab=rA5}
N 40 -7480 190 -7480 {
lab=rA6}
N 40 -7500 190 -7500 {
lab=rA7}
N 40 -7520 190 -7520 {
lab=rA8}
N 40 -7560 190 -7560 {
lab=rA10}
N 40 -7540 190 -7540 {
lab=rA9}
N 40 -7580 190 -7580 {
lab=rA11}
N 40 -7600 190 -7600 {
lab=rA12}
N 40 -7620 190 -7620 {
lab=rA13}
N 40 -7640 190 -7640 {
lab=rA14}
N 40 -7660 190 -7660 {
lab=rA15}
N 190 -7860 250 -7860 {
lab=SAMPLE}
N 190 -7840 250 -7840 {
lab=Vrminus}
N 190 -7820 250 -7820 {
lab=Vrplus}
N 40 -7380 190 -7380 {
lab=rA1}
N 190 -7380 250 -7380 {
lab=rA1}
N 190 -7400 250 -7400 {
lab=rA2}
N 190 -7420 250 -7420 {
lab=rA3}
N 190 -7440 250 -7440 {
lab=rA4}
N 190 -7460 250 -7460 {
lab=rA5}
N 190 -7480 250 -7480 {
lab=rA6}
N 190 -7500 250 -7500 {
lab=rA7}
N 190 -7520 250 -7520 {
lab=rA8}
N 190 -7540 250 -7540 {
lab=rA9}
N 190 -7560 250 -7560 {
lab=rA10}
N 190 -7580 250 -7580 {
lab=rA11}
N 190 -7600 250 -7600 {
lab=rA12}
N 190 -7620 250 -7620 {
lab=rA13}
N 190 -7640 250 -7640 {
lab=rA14}
N 190 -7660 250 -7660 {
lab=rA15}
N 30 -7650 30 -7310 {
lab=rA[0..15]
bus=true}
N 550 -7360 600 -7360 {
lab=rB0}
N 550 -7380 600 -7380 {
lab=rB1}
N 670 -7370 670 -7310 {
lab=rB[0..15]
bus=true}
N 550 -7400 600 -7400 {
lab=rB2}
N 550 -7420 600 -7420 {
lab=rB3}
N 550 -7440 600 -7440 {
lab=rB4}
N 550 -7460 600 -7460 {
lab=rB5}
N 550 -7480 600 -7480 {
lab=rB6}
N 550 -7500 600 -7500 {
lab=rB7}
N 550 -7520 600 -7520 {
lab=rB8}
N 550 -7540 600 -7540 {
lab=rB9}
N 550 -7560 600 -7560 {
lab=rB10}
N 550 -7580 600 -7580 {
lab=rB11}
N 550 -7600 600 -7600 {
lab=rB12}
N 550 -7620 600 -7620 {
lab=rB13}
N 550 -7640 600 -7640 {
lab=rB14}
N 550 -7660 600 -7660 {
lab=rB15}
N 670 -7650 670 -7370 {
lab=rB[0..15]
bus=true}
N 180 -6970 180 -6670 {bus=true
lab=cA[0..15]}
N 180 -6670 180 -6640 {bus=true
lab=cA[0..15]}
N 550 -6680 610 -6680 {
lab=cB0}
N 550 -6700 610 -6700 {
lab=cB1}
N 550 -6720 610 -6720 {
lab=cB2}
N 550 -6740 610 -6740 {
lab=cB3}
N 550 -6760 610 -6760 {
lab=cB4}
N 550 -6780 610 -6780 {
lab=cB5}
N 550 -6800 610 -6800 {
lab=cB6}
N 550 -6820 610 -6820 {
lab=cB7}
N 550 -6840 610 -6840 {
lab=cB8}
N 550 -6860 610 -6860 {
lab=cB9}
N 550 -6880 610 -6880 {
lab=cB10}
N 550 -6900 610 -6900 {
lab=cB11}
N 550 -6920 610 -6920 {
lab=cB12}
N 550 -6940 610 -6940 {
lab=cB13}
N 550 -6960 610 -6960 {
lab=cB14}
N 550 -6980 610 -6980 {
lab=cB15}
N 620 -6970 620 -6670 {bus=true
lab=cB[0..15]}
N 620 -6670 620 -6640 {bus=true
lab=cB[0..15]}
N 910 -7360 970 -7360 {
lab=rA0}
N 1320 -7360 1380 -7360 {
lab=rB0}
N 1320 -7380 1380 -7380 {
lab=rB1}
N 1320 -7400 1380 -7400 {
lab=rB2}
N 1320 -7420 1380 -7420 {
lab=rB3}
N 1320 -7440 1380 -7440 {
lab=rB4}
N 1320 -7460 1380 -7460 {
lab=rB5}
N 1320 -7480 1380 -7480 {
lab=rB6}
N 1320 -7500 1380 -7500 {
lab=rB7}
N 1320 -7520 1380 -7520 {
lab=rB8}
N 1320 -7540 1380 -7540 {
lab=rB9}
N 1320 -7560 1380 -7560 {
lab=rB10}
N 1320 -7580 1380 -7580 {
lab=rB11}
N 1320 -7600 1380 -7600 {
lab=rB12}
N 1320 -7620 1380 -7620 {
lab=rB13}
N 1320 -7640 1380 -7640 {
lab=rB14}
N 1320 -7660 1380 -7660 {
lab=rB15}
N 910 -7940 970 -7940 {
lab=col1_sel}
N 910 -7960 970 -7960 {
lab=row3_sel}
N 910 -7720 970 -7720 {
lab=Vcplus}
N 910 -7740 970 -7740 {
lab=Vcminus}
N 910 -7760 970 -7760 {
lab=Vref}
N 910 -7780 970 -7780 {
lab=Vref_comp}
N 910 -7800 970 -7800 {
lab=RISC_CLK}
N 1270 -7900 1330 -7900 {
lab=vssd1}
N 1270 -7920 1330 -7920 {
lab=vdda1}
N 1270 -7940 1330 -7940 {
lab=vccd1}
N 1270 -7960 1330 -7960 {
lab=latch_high1}
N 760 -7360 910 -7360 {
lab=rA0}
N 760 -7400 910 -7400 {
lab=rA2}
N 760 -7420 910 -7420 {
lab=rA3}
N 760 -7440 910 -7440 {
lab=rA4}
N 760 -7460 910 -7460 {
lab=rA5}
N 760 -7480 910 -7480 {
lab=rA6}
N 760 -7500 910 -7500 {
lab=rA7}
N 760 -7520 910 -7520 {
lab=rA8}
N 760 -7560 910 -7560 {
lab=rA10}
N 760 -7540 910 -7540 {
lab=rA9}
N 760 -7580 910 -7580 {
lab=rA11}
N 760 -7600 910 -7600 {
lab=rA12}
N 760 -7620 910 -7620 {
lab=rA13}
N 760 -7640 910 -7640 {
lab=rA14}
N 760 -7660 910 -7660 {
lab=rA15}
N 910 -7860 970 -7860 {
lab=SAMPLE}
N 910 -7840 970 -7840 {
lab=Vrminus}
N 910 -7820 970 -7820 {
lab=Vrplus}
N 760 -7380 910 -7380 {
lab=rA1}
N 910 -7380 970 -7380 {
lab=rA1}
N 910 -7400 970 -7400 {
lab=rA2}
N 910 -7420 970 -7420 {
lab=rA3}
N 910 -7440 970 -7440 {
lab=rA4}
N 910 -7460 970 -7460 {
lab=rA5}
N 910 -7480 970 -7480 {
lab=rA6}
N 910 -7500 970 -7500 {
lab=rA7}
N 910 -7520 970 -7520 {
lab=rA8}
N 910 -7540 970 -7540 {
lab=rA9}
N 910 -7560 970 -7560 {
lab=rA10}
N 910 -7580 970 -7580 {
lab=rA11}
N 910 -7600 970 -7600 {
lab=rA12}
N 910 -7620 970 -7620 {
lab=rA13}
N 910 -7640 970 -7640 {
lab=rA14}
N 910 -7660 970 -7660 {
lab=rA15}
N 750 -7650 750 -7310 {
lab=rA[0..15]
bus=true}
N 1270 -7360 1320 -7360 {
lab=rB0}
N 1270 -7380 1320 -7380 {
lab=rB1}
N 1390 -7370 1390 -7310 {
lab=rB[0..15]
bus=true}
N 1270 -7400 1320 -7400 {
lab=rB2}
N 1270 -7420 1320 -7420 {
lab=rB3}
N 1270 -7440 1320 -7440 {
lab=rB4}
N 1270 -7460 1320 -7460 {
lab=rB5}
N 1270 -7480 1320 -7480 {
lab=rB6}
N 1270 -7500 1320 -7500 {
lab=rB7}
N 1270 -7520 1320 -7520 {
lab=rB8}
N 1270 -7540 1320 -7540 {
lab=rB9}
N 1270 -7560 1320 -7560 {
lab=rB10}
N 1270 -7580 1320 -7580 {
lab=rB11}
N 1270 -7600 1320 -7600 {
lab=rB12}
N 1270 -7620 1320 -7620 {
lab=rB13}
N 1270 -7640 1320 -7640 {
lab=rB14}
N 1270 -7660 1320 -7660 {
lab=rB15}
N 1390 -7650 1390 -7370 {
lab=rB[0..15]
bus=true}
N 910 -7900 970 -7900 {
lab=WR}
N 910 -7920 970 -7920 {
lab=Vgnr}
N 910 -7880 970 -7880 {
lab=Vgpr}
N 1610 -7930 1670 -7930 {
lab=col2_sel}
N 1610 -7950 1670 -7950 {
lab=row3_sel}
N 1610 -7710 1670 -7710 {
lab=Vcplus}
N 1610 -7730 1670 -7730 {
lab=Vcminus}
N 1610 -7750 1670 -7750 {
lab=Vref}
N 1610 -7770 1670 -7770 {
lab=Vref_comp}
N 1610 -7790 1670 -7790 {
lab=RISC_CLK}
N 1610 -7850 1670 -7850 {
lab=SAMPLE}
N 1610 -7830 1670 -7830 {
lab=Vrminus}
N 1610 -7810 1670 -7810 {
lab=Vrplus}
N 1610 -7890 1670 -7890 {
lab=WR}
N 1610 -7910 1670 -7910 {
lab=Vgnr}
N 1610 -7870 1670 -7870 {
lab=Vgpr}
N 1970 -7890 2030 -7890 {
lab=vssd1}
N 1970 -7910 2030 -7910 {
lab=vdda1}
N 1970 -7930 2030 -7930 {
lab=vccd1}
N 1610 -7350 1670 -7350 {
lab=rA0}
N 2020 -7350 2080 -7350 {
lab=rB0}
N 2020 -7370 2080 -7370 {
lab=rB1}
N 2020 -7390 2080 -7390 {
lab=rB2}
N 2020 -7410 2080 -7410 {
lab=rB3}
N 2020 -7430 2080 -7430 {
lab=rB4}
N 2020 -7450 2080 -7450 {
lab=rB5}
N 2020 -7470 2080 -7470 {
lab=rB6}
N 2020 -7490 2080 -7490 {
lab=rB7}
N 2020 -7510 2080 -7510 {
lab=rB8}
N 2020 -7530 2080 -7530 {
lab=rB9}
N 2020 -7550 2080 -7550 {
lab=rB10}
N 2020 -7570 2080 -7570 {
lab=rB11}
N 2020 -7590 2080 -7590 {
lab=rB12}
N 2020 -7610 2080 -7610 {
lab=rB13}
N 2020 -7630 2080 -7630 {
lab=rB14}
N 2020 -7650 2080 -7650 {
lab=rB15}
N 1460 -7350 1610 -7350 {
lab=rA0}
N 1460 -7390 1610 -7390 {
lab=rA2}
N 1460 -7410 1610 -7410 {
lab=rA3}
N 1460 -7430 1610 -7430 {
lab=rA4}
N 1460 -7450 1610 -7450 {
lab=rA5}
N 1460 -7470 1610 -7470 {
lab=rA6}
N 1460 -7490 1610 -7490 {
lab=rA7}
N 1460 -7510 1610 -7510 {
lab=rA8}
N 1460 -7550 1610 -7550 {
lab=rA10}
N 1460 -7530 1610 -7530 {
lab=rA9}
N 1460 -7570 1610 -7570 {
lab=rA11}
N 1460 -7590 1610 -7590 {
lab=rA12}
N 1460 -7610 1610 -7610 {
lab=rA13}
N 1460 -7630 1610 -7630 {
lab=rA14}
N 1460 -7650 1610 -7650 {
lab=rA15}
N 1460 -7370 1610 -7370 {
lab=rA1}
N 1610 -7370 1670 -7370 {
lab=rA1}
N 1610 -7390 1670 -7390 {
lab=rA2}
N 1610 -7410 1670 -7410 {
lab=rA3}
N 1610 -7430 1670 -7430 {
lab=rA4}
N 1610 -7450 1670 -7450 {
lab=rA5}
N 1610 -7470 1670 -7470 {
lab=rA6}
N 1610 -7490 1670 -7490 {
lab=rA7}
N 1610 -7510 1670 -7510 {
lab=rA8}
N 1610 -7530 1670 -7530 {
lab=rA9}
N 1610 -7550 1670 -7550 {
lab=rA10}
N 1610 -7570 1670 -7570 {
lab=rA11}
N 1610 -7590 1670 -7590 {
lab=rA12}
N 1610 -7610 1670 -7610 {
lab=rA13}
N 1610 -7630 1670 -7630 {
lab=rA14}
N 1610 -7650 1670 -7650 {
lab=rA15}
N 1450 -7640 1450 -7300 {
lab=rA[0..15]
bus=true}
N 1970 -7350 2020 -7350 {
lab=rB0}
N 1970 -7370 2020 -7370 {
lab=rB1}
N 2090 -7360 2090 -7300 {
lab=rB[0..15]
bus=true}
N 1970 -7390 2020 -7390 {
lab=rB2}
N 1970 -7410 2020 -7410 {
lab=rB3}
N 1970 -7430 2020 -7430 {
lab=rB4}
N 1970 -7450 2020 -7450 {
lab=rB5}
N 1970 -7470 2020 -7470 {
lab=rB6}
N 1970 -7490 2020 -7490 {
lab=rB7}
N 1970 -7510 2020 -7510 {
lab=rB8}
N 1970 -7530 2020 -7530 {
lab=rB9}
N 1970 -7550 2020 -7550 {
lab=rB10}
N 1970 -7570 2020 -7570 {
lab=rB11}
N 1970 -7590 2020 -7590 {
lab=rB12}
N 1970 -7610 2020 -7610 {
lab=rB13}
N 1970 -7630 2020 -7630 {
lab=rB14}
N 1970 -7650 2020 -7650 {
lab=rB15}
N 2090 -7640 2090 -7360 {
lab=rB[0..15]
bus=true}
N 910 -6680 970 -6680 {
lab=cA0}
N 910 -6700 970 -6700 {
lab=cA1}
N 910 -6720 970 -6720 {
lab=cA2}
N 910 -6740 970 -6740 {
lab=cA3}
N 910 -6760 970 -6760 {
lab=cA4}
N 910 -6780 970 -6780 {
lab=cA5}
N 910 -6800 970 -6800 {
lab=cA6}
N 910 -6820 970 -6820 {
lab=cA7}
N 910 -6840 970 -6840 {
lab=cA8}
N 910 -6860 970 -6860 {
lab=cA9}
N 910 -6880 970 -6880 {
lab=cA10}
N 910 -6900 970 -6900 {
lab=cA11}
N 910 -6920 970 -6920 {
lab=cA12}
N 910 -6940 970 -6940 {
lab=cA13}
N 910 -6960 970 -6960 {
lab=cA14}
N 910 -6980 970 -6980 {
lab=cA15}
N 900 -6970 900 -6670 {bus=true
lab=cA[0..15]}
N 900 -6670 900 -6640 {bus=true
lab=cA[0..15]}
N 1270 -6680 1330 -6680 {
lab=cB0}
N 1270 -6700 1330 -6700 {
lab=cB1}
N 1270 -6720 1330 -6720 {
lab=cB2}
N 1270 -6740 1330 -6740 {
lab=cB3}
N 1270 -6760 1330 -6760 {
lab=cB4}
N 1270 -6780 1330 -6780 {
lab=cB5}
N 1270 -6800 1330 -6800 {
lab=cB6}
N 1270 -6820 1330 -6820 {
lab=cB7}
N 1270 -6840 1330 -6840 {
lab=cB8}
N 1270 -6860 1330 -6860 {
lab=cB9}
N 1270 -6880 1330 -6880 {
lab=cB10}
N 1270 -6900 1330 -6900 {
lab=cB11}
N 1270 -6920 1330 -6920 {
lab=cB12}
N 1270 -6940 1330 -6940 {
lab=cB13}
N 1270 -6960 1330 -6960 {
lab=cB14}
N 1270 -6980 1330 -6980 {
lab=cB15}
N 1340 -6970 1340 -6670 {bus=true
lab=cB[0..15]}
N 1340 -6670 1340 -6640 {bus=true
lab=cB[0..15]}
N 1610 -6670 1670 -6670 {
lab=cA0}
N 1610 -6690 1670 -6690 {
lab=cA1}
N 1610 -6710 1670 -6710 {
lab=cA2}
N 1610 -6730 1670 -6730 {
lab=cA3}
N 1610 -6750 1670 -6750 {
lab=cA4}
N 1610 -6770 1670 -6770 {
lab=cA5}
N 1610 -6790 1670 -6790 {
lab=cA6}
N 1610 -6810 1670 -6810 {
lab=cA7}
N 1610 -6830 1670 -6830 {
lab=cA8}
N 1610 -6850 1670 -6850 {
lab=cA9}
N 1610 -6870 1670 -6870 {
lab=cA10}
N 1610 -6890 1670 -6890 {
lab=cA11}
N 1610 -6910 1670 -6910 {
lab=cA12}
N 1610 -6930 1670 -6930 {
lab=cA13}
N 1610 -6950 1670 -6950 {
lab=cA14}
N 1610 -6970 1670 -6970 {
lab=cA15}
N 1600 -6960 1600 -6660 {bus=true
lab=cA[0..15]}
N 1600 -6660 1600 -6630 {bus=true
lab=cA[0..15]}
N 1970 -6670 2030 -6670 {
lab=cB0}
N 1970 -6690 2030 -6690 {
lab=cB1}
N 1970 -6710 2030 -6710 {
lab=cB2}
N 1970 -6730 2030 -6730 {
lab=cB3}
N 1970 -6750 2030 -6750 {
lab=cB4}
N 1970 -6770 2030 -6770 {
lab=cB5}
N 1970 -6790 2030 -6790 {
lab=cB6}
N 1970 -6810 2030 -6810 {
lab=cB7}
N 1970 -6830 2030 -6830 {
lab=cB8}
N 1970 -6850 2030 -6850 {
lab=cB9}
N 1970 -6870 2030 -6870 {
lab=cB10}
N 1970 -6890 2030 -6890 {
lab=cB11}
N 1970 -6910 2030 -6910 {
lab=cB12}
N 1970 -6930 2030 -6930 {
lab=cB13}
N 1970 -6950 2030 -6950 {
lab=cB14}
N 1970 -6970 2030 -6970 {
lab=cB15}
N 2040 -6960 2040 -6660 {bus=true
lab=cB[0..15]}
N 2040 -6660 2040 -6630 {bus=true
lab=cB[0..15]}
N 2340 -7360 2400 -7360 {
lab=rA0}
N 2750 -7360 2810 -7360 {
lab=rB0}
N 2750 -7380 2810 -7380 {
lab=rB1}
N 2750 -7400 2810 -7400 {
lab=rB2}
N 2750 -7420 2810 -7420 {
lab=rB3}
N 2750 -7440 2810 -7440 {
lab=rB4}
N 2750 -7460 2810 -7460 {
lab=rB5}
N 2750 -7480 2810 -7480 {
lab=rB6}
N 2750 -7500 2810 -7500 {
lab=rB7}
N 2750 -7520 2810 -7520 {
lab=rB8}
N 2750 -7540 2810 -7540 {
lab=rB9}
N 2750 -7560 2810 -7560 {
lab=rB10}
N 2750 -7580 2810 -7580 {
lab=rB11}
N 2750 -7600 2810 -7600 {
lab=rB12}
N 2750 -7620 2810 -7620 {
lab=rB13}
N 2750 -7640 2810 -7640 {
lab=rB14}
N 2750 -7660 2810 -7660 {
lab=rB15}
N 2190 -7360 2340 -7360 {
lab=rA0}
N 2190 -7400 2340 -7400 {
lab=rA2}
N 2190 -7420 2340 -7420 {
lab=rA3}
N 2190 -7440 2340 -7440 {
lab=rA4}
N 2190 -7460 2340 -7460 {
lab=rA5}
N 2190 -7480 2340 -7480 {
lab=rA6}
N 2190 -7500 2340 -7500 {
lab=rA7}
N 2190 -7520 2340 -7520 {
lab=rA8}
N 2190 -7560 2340 -7560 {
lab=rA10}
N 2190 -7540 2340 -7540 {
lab=rA9}
N 2190 -7580 2340 -7580 {
lab=rA11}
N 2190 -7600 2340 -7600 {
lab=rA12}
N 2190 -7620 2340 -7620 {
lab=rA13}
N 2190 -7640 2340 -7640 {
lab=rA14}
N 2190 -7660 2340 -7660 {
lab=rA15}
N 2190 -7380 2340 -7380 {
lab=rA1}
N 2340 -7380 2400 -7380 {
lab=rA1}
N 2340 -7400 2400 -7400 {
lab=rA2}
N 2340 -7420 2400 -7420 {
lab=rA3}
N 2340 -7440 2400 -7440 {
lab=rA4}
N 2340 -7460 2400 -7460 {
lab=rA5}
N 2340 -7480 2400 -7480 {
lab=rA6}
N 2340 -7500 2400 -7500 {
lab=rA7}
N 2340 -7520 2400 -7520 {
lab=rA8}
N 2340 -7540 2400 -7540 {
lab=rA9}
N 2340 -7560 2400 -7560 {
lab=rA10}
N 2340 -7580 2400 -7580 {
lab=rA11}
N 2340 -7600 2400 -7600 {
lab=rA12}
N 2340 -7620 2400 -7620 {
lab=rA13}
N 2340 -7640 2400 -7640 {
lab=rA14}
N 2340 -7660 2400 -7660 {
lab=rA15}
N 2180 -7650 2180 -7310 {
lab=rA[0..15]
bus=true}
N 2700 -7360 2750 -7360 {
lab=rB0}
N 2700 -7380 2750 -7380 {
lab=rB1}
N 2820 -7370 2820 -7310 {
lab=rB[0..15]
bus=true}
N 2700 -7400 2750 -7400 {
lab=rB2}
N 2700 -7420 2750 -7420 {
lab=rB3}
N 2700 -7440 2750 -7440 {
lab=rB4}
N 2700 -7460 2750 -7460 {
lab=rB5}
N 2700 -7480 2750 -7480 {
lab=rB6}
N 2700 -7500 2750 -7500 {
lab=rB7}
N 2700 -7520 2750 -7520 {
lab=rB8}
N 2700 -7540 2750 -7540 {
lab=rB9}
N 2700 -7560 2750 -7560 {
lab=rB10}
N 2700 -7580 2750 -7580 {
lab=rB11}
N 2700 -7600 2750 -7600 {
lab=rB12}
N 2700 -7620 2750 -7620 {
lab=rB13}
N 2700 -7640 2750 -7640 {
lab=rB14}
N 2700 -7660 2750 -7660 {
lab=rB15}
N 2820 -7650 2820 -7370 {
lab=rB[0..15]
bus=true}
N 2340 -6680 2400 -6680 {
lab=cA0}
N 2340 -6700 2400 -6700 {
lab=cA1}
N 2340 -6720 2400 -6720 {
lab=cA2}
N 2340 -6740 2400 -6740 {
lab=cA3}
N 2340 -6760 2400 -6760 {
lab=cA4}
N 2340 -6780 2400 -6780 {
lab=cA5}
N 2340 -6800 2400 -6800 {
lab=cA6}
N 2340 -6820 2400 -6820 {
lab=cA7}
N 2340 -6840 2400 -6840 {
lab=cA8}
N 2340 -6860 2400 -6860 {
lab=cA9}
N 2340 -6880 2400 -6880 {
lab=cA10}
N 2340 -6900 2400 -6900 {
lab=cA11}
N 2340 -6920 2400 -6920 {
lab=cA12}
N 2340 -6940 2400 -6940 {
lab=cA13}
N 2340 -6960 2400 -6960 {
lab=cA14}
N 2340 -6980 2400 -6980 {
lab=cA15}
N 2330 -6970 2330 -6670 {bus=true
lab=cA[0..15]}
N 2330 -6670 2330 -6640 {bus=true
lab=cA[0..15]}
N 2700 -6680 2760 -6680 {
lab=cB0}
N 2700 -6700 2760 -6700 {
lab=cB1}
N 2700 -6720 2760 -6720 {
lab=cB2}
N 2700 -6740 2760 -6740 {
lab=cB3}
N 2700 -6760 2760 -6760 {
lab=cB4}
N 2700 -6780 2760 -6780 {
lab=cB5}
N 2700 -6800 2760 -6800 {
lab=cB6}
N 2700 -6820 2760 -6820 {
lab=cB7}
N 2700 -6840 2760 -6840 {
lab=cB8}
N 2700 -6860 2760 -6860 {
lab=cB9}
N 2700 -6880 2760 -6880 {
lab=cB10}
N 2700 -6900 2760 -6900 {
lab=cB11}
N 2700 -6920 2760 -6920 {
lab=cB12}
N 2700 -6940 2760 -6940 {
lab=cB13}
N 2700 -6960 2760 -6960 {
lab=cB14}
N 2700 -6980 2760 -6980 {
lab=cB15}
N 2770 -6970 2770 -6670 {bus=true
lab=cB[0..15]}
N 2770 -6670 2770 -6640 {bus=true
lab=cB[0..15]}
N 3040 -7350 3100 -7350 {
lab=rA0}
N 3450 -7350 3510 -7350 {
lab=rB0}
N 3450 -7370 3510 -7370 {
lab=rB1}
N 3450 -7390 3510 -7390 {
lab=rB2}
N 3450 -7410 3510 -7410 {
lab=rB3}
N 3450 -7430 3510 -7430 {
lab=rB4}
N 3450 -7450 3510 -7450 {
lab=rB5}
N 3450 -7470 3510 -7470 {
lab=rB6}
N 3450 -7490 3510 -7490 {
lab=rB7}
N 3450 -7510 3510 -7510 {
lab=rB8}
N 3450 -7530 3510 -7530 {
lab=rB9}
N 3450 -7550 3510 -7550 {
lab=rB10}
N 3450 -7570 3510 -7570 {
lab=rB11}
N 3450 -7590 3510 -7590 {
lab=rB12}
N 3450 -7610 3510 -7610 {
lab=rB13}
N 3450 -7630 3510 -7630 {
lab=rB14}
N 3450 -7650 3510 -7650 {
lab=rB15}
N 2890 -7350 3040 -7350 {
lab=rA0}
N 2890 -7390 3040 -7390 {
lab=rA2}
N 2890 -7410 3040 -7410 {
lab=rA3}
N 2890 -7430 3040 -7430 {
lab=rA4}
N 2890 -7450 3040 -7450 {
lab=rA5}
N 2890 -7470 3040 -7470 {
lab=rA6}
N 2890 -7490 3040 -7490 {
lab=rA7}
N 2890 -7510 3040 -7510 {
lab=rA8}
N 2890 -7550 3040 -7550 {
lab=rA10}
N 2890 -7530 3040 -7530 {
lab=rA9}
N 2890 -7570 3040 -7570 {
lab=rA11}
N 2890 -7590 3040 -7590 {
lab=rA12}
N 2890 -7610 3040 -7610 {
lab=rA13}
N 2890 -7630 3040 -7630 {
lab=rA14}
N 2890 -7650 3040 -7650 {
lab=rA15}
N 2890 -7370 3040 -7370 {
lab=rA1}
N 3040 -7370 3100 -7370 {
lab=rA1}
N 3040 -7390 3100 -7390 {
lab=rA2}
N 3040 -7410 3100 -7410 {
lab=rA3}
N 3040 -7430 3100 -7430 {
lab=rA4}
N 3040 -7450 3100 -7450 {
lab=rA5}
N 3040 -7470 3100 -7470 {
lab=rA6}
N 3040 -7490 3100 -7490 {
lab=rA7}
N 3040 -7510 3100 -7510 {
lab=rA8}
N 3040 -7530 3100 -7530 {
lab=rA9}
N 3040 -7550 3100 -7550 {
lab=rA10}
N 3040 -7570 3100 -7570 {
lab=rA11}
N 3040 -7590 3100 -7590 {
lab=rA12}
N 3040 -7610 3100 -7610 {
lab=rA13}
N 3040 -7630 3100 -7630 {
lab=rA14}
N 3040 -7650 3100 -7650 {
lab=rA15}
N 2880 -7640 2880 -7300 {
lab=rA[0..15]
bus=true}
N 3400 -7350 3450 -7350 {
lab=rB0}
N 3400 -7370 3450 -7370 {
lab=rB1}
N 3520 -7360 3520 -7300 {
lab=rB[0..15]
bus=true}
N 3400 -7390 3450 -7390 {
lab=rB2}
N 3400 -7410 3450 -7410 {
lab=rB3}
N 3400 -7430 3450 -7430 {
lab=rB4}
N 3400 -7450 3450 -7450 {
lab=rB5}
N 3400 -7470 3450 -7470 {
lab=rB6}
N 3400 -7490 3450 -7490 {
lab=rB7}
N 3400 -7510 3450 -7510 {
lab=rB8}
N 3400 -7530 3450 -7530 {
lab=rB9}
N 3400 -7550 3450 -7550 {
lab=rB10}
N 3400 -7570 3450 -7570 {
lab=rB11}
N 3400 -7590 3450 -7590 {
lab=rB12}
N 3400 -7610 3450 -7610 {
lab=rB13}
N 3400 -7630 3450 -7630 {
lab=rB14}
N 3400 -7650 3450 -7650 {
lab=rB15}
N 3520 -7640 3520 -7360 {
lab=rB[0..15]
bus=true}
N 3040 -6670 3100 -6670 {
lab=cA0}
N 3040 -6690 3100 -6690 {
lab=cA1}
N 3040 -6710 3100 -6710 {
lab=cA2}
N 3040 -6730 3100 -6730 {
lab=cA3}
N 3040 -6750 3100 -6750 {
lab=cA4}
N 3040 -6770 3100 -6770 {
lab=cA5}
N 3040 -6790 3100 -6790 {
lab=cA6}
N 3040 -6810 3100 -6810 {
lab=cA7}
N 3040 -6830 3100 -6830 {
lab=cA8}
N 3040 -6850 3100 -6850 {
lab=cA9}
N 3040 -6870 3100 -6870 {
lab=cA10}
N 3040 -6890 3100 -6890 {
lab=cA11}
N 3040 -6910 3100 -6910 {
lab=cA12}
N 3040 -6930 3100 -6930 {
lab=cA13}
N 3040 -6950 3100 -6950 {
lab=cA14}
N 3040 -6970 3100 -6970 {
lab=cA15}
N 3030 -6960 3030 -6660 {bus=true
lab=cA[0..15]}
N 3030 -6660 3030 -6630 {bus=true
lab=cA[0..15]}
N 3400 -6670 3460 -6670 {
lab=cB0}
N 3400 -6690 3460 -6690 {
lab=cB1}
N 3400 -6710 3460 -6710 {
lab=cB2}
N 3400 -6730 3460 -6730 {
lab=cB3}
N 3400 -6750 3460 -6750 {
lab=cB4}
N 3400 -6770 3460 -6770 {
lab=cB5}
N 3400 -6790 3460 -6790 {
lab=cB6}
N 3400 -6810 3460 -6810 {
lab=cB7}
N 3400 -6830 3460 -6830 {
lab=cB8}
N 3400 -6850 3460 -6850 {
lab=cB9}
N 3400 -6870 3460 -6870 {
lab=cB10}
N 3400 -6890 3460 -6890 {
lab=cB11}
N 3400 -6910 3460 -6910 {
lab=cB12}
N 3400 -6930 3460 -6930 {
lab=cB13}
N 3400 -6950 3460 -6950 {
lab=cB14}
N 3400 -6970 3460 -6970 {
lab=cB15}
N 3470 -6960 3470 -6660 {bus=true
lab=cB[0..15]}
N 3470 -6660 3470 -6630 {bus=true
lab=cB[0..15]}
N 3750 -7350 3810 -7350 {
lab=rA0}
N 4160 -7350 4220 -7350 {
lab=rB0}
N 4160 -7370 4220 -7370 {
lab=rB1}
N 4160 -7390 4220 -7390 {
lab=rB2}
N 4160 -7410 4220 -7410 {
lab=rB3}
N 4160 -7430 4220 -7430 {
lab=rB4}
N 4160 -7450 4220 -7450 {
lab=rB5}
N 4160 -7470 4220 -7470 {
lab=rB6}
N 4160 -7490 4220 -7490 {
lab=rB7}
N 4160 -7510 4220 -7510 {
lab=rB8}
N 4160 -7530 4220 -7530 {
lab=rB9}
N 4160 -7550 4220 -7550 {
lab=rB10}
N 4160 -7570 4220 -7570 {
lab=rB11}
N 4160 -7590 4220 -7590 {
lab=rB12}
N 4160 -7610 4220 -7610 {
lab=rB13}
N 4160 -7630 4220 -7630 {
lab=rB14}
N 4160 -7650 4220 -7650 {
lab=rB15}
N 3600 -7350 3750 -7350 {
lab=rA0}
N 3600 -7390 3750 -7390 {
lab=rA2}
N 3600 -7410 3750 -7410 {
lab=rA3}
N 3600 -7430 3750 -7430 {
lab=rA4}
N 3600 -7450 3750 -7450 {
lab=rA5}
N 3600 -7470 3750 -7470 {
lab=rA6}
N 3600 -7490 3750 -7490 {
lab=rA7}
N 3600 -7510 3750 -7510 {
lab=rA8}
N 3600 -7550 3750 -7550 {
lab=rA10}
N 3600 -7530 3750 -7530 {
lab=rA9}
N 3600 -7570 3750 -7570 {
lab=rA11}
N 3600 -7590 3750 -7590 {
lab=rA12}
N 3600 -7610 3750 -7610 {
lab=rA13}
N 3600 -7630 3750 -7630 {
lab=rA14}
N 3600 -7650 3750 -7650 {
lab=rA15}
N 3600 -7370 3750 -7370 {
lab=rA1}
N 3750 -7370 3810 -7370 {
lab=rA1}
N 3750 -7390 3810 -7390 {
lab=rA2}
N 3750 -7410 3810 -7410 {
lab=rA3}
N 3750 -7430 3810 -7430 {
lab=rA4}
N 3750 -7450 3810 -7450 {
lab=rA5}
N 3750 -7470 3810 -7470 {
lab=rA6}
N 3750 -7490 3810 -7490 {
lab=rA7}
N 3750 -7510 3810 -7510 {
lab=rA8}
N 3750 -7530 3810 -7530 {
lab=rA9}
N 3750 -7550 3810 -7550 {
lab=rA10}
N 3750 -7570 3810 -7570 {
lab=rA11}
N 3750 -7590 3810 -7590 {
lab=rA12}
N 3750 -7610 3810 -7610 {
lab=rA13}
N 3750 -7630 3810 -7630 {
lab=rA14}
N 3750 -7650 3810 -7650 {
lab=rA15}
N 3590 -7640 3590 -7300 {
lab=rA[0..15]
bus=true}
N 4110 -7350 4160 -7350 {
lab=rB0}
N 4110 -7370 4160 -7370 {
lab=rB1}
N 4230 -7360 4230 -7300 {
lab=rB[0..15]
bus=true}
N 4110 -7390 4160 -7390 {
lab=rB2}
N 4110 -7410 4160 -7410 {
lab=rB3}
N 4110 -7430 4160 -7430 {
lab=rB4}
N 4110 -7450 4160 -7450 {
lab=rB5}
N 4110 -7470 4160 -7470 {
lab=rB6}
N 4110 -7490 4160 -7490 {
lab=rB7}
N 4110 -7510 4160 -7510 {
lab=rB8}
N 4110 -7530 4160 -7530 {
lab=rB9}
N 4110 -7550 4160 -7550 {
lab=rB10}
N 4110 -7570 4160 -7570 {
lab=rB11}
N 4110 -7590 4160 -7590 {
lab=rB12}
N 4110 -7610 4160 -7610 {
lab=rB13}
N 4110 -7630 4160 -7630 {
lab=rB14}
N 4110 -7650 4160 -7650 {
lab=rB15}
N 4230 -7640 4230 -7360 {
lab=rB[0..15]
bus=true}
N 3750 -6670 3810 -6670 {
lab=cA0}
N 3750 -6690 3810 -6690 {
lab=cA1}
N 3750 -6710 3810 -6710 {
lab=cA2}
N 3750 -6730 3810 -6730 {
lab=cA3}
N 3750 -6750 3810 -6750 {
lab=cA4}
N 3750 -6770 3810 -6770 {
lab=cA5}
N 3750 -6790 3810 -6790 {
lab=cA6}
N 3750 -6810 3810 -6810 {
lab=cA7}
N 3750 -6830 3810 -6830 {
lab=cA8}
N 3750 -6850 3810 -6850 {
lab=cA9}
N 3750 -6870 3810 -6870 {
lab=cA10}
N 3750 -6890 3810 -6890 {
lab=cA11}
N 3750 -6910 3810 -6910 {
lab=cA12}
N 3750 -6930 3810 -6930 {
lab=cA13}
N 3750 -6950 3810 -6950 {
lab=cA14}
N 3750 -6970 3810 -6970 {
lab=cA15}
N 3740 -6960 3740 -6660 {bus=true
lab=cA[0..15]}
N 3740 -6660 3740 -6630 {bus=true
lab=cA[0..15]}
N 4110 -6670 4170 -6670 {
lab=cB0}
N 4110 -6690 4170 -6690 {
lab=cB1}
N 4110 -6710 4170 -6710 {
lab=cB2}
N 4110 -6730 4170 -6730 {
lab=cB3}
N 4110 -6750 4170 -6750 {
lab=cB4}
N 4110 -6770 4170 -6770 {
lab=cB5}
N 4110 -6790 4170 -6790 {
lab=cB6}
N 4110 -6810 4170 -6810 {
lab=cB7}
N 4110 -6830 4170 -6830 {
lab=cB8}
N 4110 -6850 4170 -6850 {
lab=cB9}
N 4110 -6870 4170 -6870 {
lab=cB10}
N 4110 -6890 4170 -6890 {
lab=cB11}
N 4110 -6910 4170 -6910 {
lab=cB12}
N 4110 -6930 4170 -6930 {
lab=cB13}
N 4110 -6950 4170 -6950 {
lab=cB14}
N 4110 -6970 4170 -6970 {
lab=cB15}
N 4180 -6960 4180 -6660 {bus=true
lab=cB[0..15]}
N 4180 -6660 4180 -6630 {bus=true
lab=cB[0..15]}
N 2340 -7940 2400 -7940 {
lab=col3_sel}
N 2340 -7960 2400 -7960 {
lab=row3_sel}
N 2340 -7720 2400 -7720 {
lab=Vcplus}
N 2340 -7740 2400 -7740 {
lab=Vcminus}
N 2340 -7760 2400 -7760 {
lab=Vref}
N 2340 -7780 2400 -7780 {
lab=Vref_comp}
N 2340 -7800 2400 -7800 {
lab=RISC_CLK}
N 2340 -7860 2400 -7860 {
lab=SAMPLE}
N 2340 -7840 2400 -7840 {
lab=Vrminus}
N 2340 -7820 2400 -7820 {
lab=Vrplus}
N 2340 -7900 2400 -7900 {
lab=WR}
N 2340 -7920 2400 -7920 {
lab=Vgnr}
N 2340 -7880 2400 -7880 {
lab=Vgpr}
N 3040 -7930 3100 -7930 {
lab=col4_sel}
N 3040 -7950 3100 -7950 {
lab=row3_sel}
N 3040 -7710 3100 -7710 {
lab=Vcplus}
N 3040 -7730 3100 -7730 {
lab=Vcminus}
N 3040 -7750 3100 -7750 {
lab=Vref}
N 3040 -7770 3100 -7770 {
lab=Vref_comp}
N 3040 -7790 3100 -7790 {
lab=RISC_CLK}
N 3040 -7850 3100 -7850 {
lab=SAMPLE}
N 3040 -7830 3100 -7830 {
lab=Vrminus}
N 3040 -7810 3100 -7810 {
lab=Vrplus}
N 3040 -7890 3100 -7890 {
lab=WR}
N 3040 -7910 3100 -7910 {
lab=Vgnr}
N 3040 -7870 3100 -7870 {
lab=Vgpr}
N 3750 -7930 3810 -7930 {
lab=col5_sel}
N 3750 -7950 3810 -7950 {
lab=row3_sel}
N 3750 -7710 3810 -7710 {
lab=Vcplus}
N 3750 -7730 3810 -7730 {
lab=Vcminus}
N 3750 -7750 3810 -7750 {
lab=Vref}
N 3750 -7770 3810 -7770 {
lab=Vref_comp}
N 3750 -7790 3810 -7790 {
lab=RISC_CLK}
N 3750 -7850 3810 -7850 {
lab=SAMPLE}
N 3750 -7830 3810 -7830 {
lab=Vrminus}
N 3750 -7810 3810 -7810 {
lab=Vrplus}
N 3750 -7890 3810 -7890 {
lab=WR}
N 3750 -7910 3810 -7910 {
lab=Vgnr}
N 3750 -7870 3810 -7870 {
lab=Vgpr}
N 190 -9350 250 -9350 {
lab=rA0}
N 600 -9350 660 -9350 {
lab=rB0}
N 600 -9370 660 -9370 {
lab=rB1}
N 600 -9390 660 -9390 {
lab=rB2}
N 600 -9410 660 -9410 {
lab=rB3}
N 600 -9430 660 -9430 {
lab=rB4}
N 600 -9450 660 -9450 {
lab=rB5}
N 600 -9470 660 -9470 {
lab=rB6}
N 600 -9490 660 -9490 {
lab=rB7}
N 600 -9510 660 -9510 {
lab=rB8}
N 600 -9530 660 -9530 {
lab=rB9}
N 600 -9550 660 -9550 {
lab=rB10}
N 600 -9570 660 -9570 {
lab=rB11}
N 600 -9590 660 -9590 {
lab=rB12}
N 600 -9610 660 -9610 {
lab=rB13}
N 600 -9630 660 -9630 {
lab=rB14}
N 600 -9650 660 -9650 {
lab=rB15}
N 190 -9010 250 -9010 {
lab=WL0}
N 190 -9030 250 -9030 {
lab=WL1}
N 190 -9050 250 -9050 {
lab=WL2}
N 190 -9070 250 -9070 {
lab=WL3}
N 190 -9090 250 -9090 {
lab=WL4}
N 190 -9110 250 -9110 {
lab=WL5}
N 190 -9130 250 -9130 {
lab=WL6}
N 190 -9150 250 -9150 {
lab=WL7}
N 190 -9170 250 -9170 {
lab=WL8}
N 190 -9190 250 -9190 {
lab=WL9}
N 190 -9210 250 -9210 {
lab=WL10}
N 190 -9230 250 -9230 {
lab=WL11}
N 190 -9250 250 -9250 {
lab=WL12}
N 190 -9270 250 -9270 {
lab=WL13}
N 190 -9290 250 -9290 {
lab=WL14}
N 190 -9310 250 -9310 {
lab=WL15}
N 190 -8670 250 -8670 {
lab=cA0}
N 190 -8690 250 -8690 {
lab=cA1}
N 190 -8710 250 -8710 {
lab=cA2}
N 190 -8730 250 -8730 {
lab=cA3}
N 190 -8750 250 -8750 {
lab=cA4}
N 190 -8770 250 -8770 {
lab=cA5}
N 190 -8790 250 -8790 {
lab=cA6}
N 190 -8810 250 -8810 {
lab=cA7}
N 190 -8830 250 -8830 {
lab=cA8}
N 190 -8850 250 -8850 {
lab=cA9}
N 190 -8870 250 -8870 {
lab=cA10}
N 190 -8890 250 -8890 {
lab=cA11}
N 190 -8910 250 -8910 {
lab=cA12}
N 190 -8930 250 -8930 {
lab=cA13}
N 190 -8950 250 -8950 {
lab=cA14}
N 190 -8970 250 -8970 {
lab=cA15}
N 190 -9930 250 -9930 {
lab=col0_sel}
N 190 -9950 250 -9950 {
lab=row4_sel}
N 190 -9890 250 -9890 {
lab=WR}
N 190 -9910 250 -9910 {
lab=Vgnr}
N 190 -9870 250 -9870 {
lab=Vgpr}
N 190 -9710 250 -9710 {
lab=Vcplus}
N 190 -9730 250 -9730 {
lab=Vcminus}
N 190 -9750 250 -9750 {
lab=Vref}
N 190 -9770 250 -9770 {
lab=Vref_comp}
N 190 -9790 250 -9790 {
lab=RISC_CLK}
N 550 -9890 610 -9890 {
lab=vssd1}
N 550 -9910 610 -9910 {
lab=vdda1}
N 550 -9930 610 -9930 {
lab=vccd1}
N 550 -9950 610 -9950 {
lab=latch_high0}
N 1970 -9940 2030 -9940 {
lab=latch_high2}
N 2700 -9890 2760 -9890 {
lab=vssd1}
N 2700 -9910 2760 -9910 {
lab=vdda1}
N 2700 -9930 2760 -9930 {
lab=vccd1}
N 2700 -9950 2760 -9950 {
lab=latch_high3}
N 3400 -9880 3460 -9880 {
lab=vssd1}
N 3400 -9900 3460 -9900 {
lab=vdda1}
N 3400 -9920 3460 -9920 {
lab=vccd1}
N 3400 -9940 3460 -9940 {
lab=latch_high4}
N 4110 -9880 4170 -9880 {
lab=vssd1}
N 4110 -9900 4170 -9900 {
lab=vdda1}
N 4110 -9920 4170 -9920 {
lab=vccd1}
N 4110 -9940 4170 -9940 {
lab=latch_high5}
N 130 -9010 190 -9010 {
lab=WL0}
N 130 -9030 190 -9030 {
lab=WL1}
N 130 -9050 190 -9050 {
lab=WL2}
N 130 -9070 190 -9070 {
lab=WL3}
N 130 -9090 190 -9090 {
lab=WL4}
N 130 -9110 190 -9110 {
lab=WL5}
N 130 -9130 190 -9130 {
lab=WL6}
N 130 -9150 190 -9150 {
lab=WL7}
N 130 -9170 190 -9170 {
lab=WL8}
N 130 -9190 190 -9190 {
lab=WL9}
N 130 -9210 190 -9210 {
lab=WL10}
N 130 -9230 190 -9230 {
lab=WL11}
N 130 -9250 190 -9250 {
lab=WL12}
N 130 -9270 190 -9270 {
lab=WL13}
N 130 -9290 190 -9290 {
lab=WL14}
N 130 -9310 190 -9310 {
lab=WL15}
N 70 -9010 130 -9010 {
lab=WL0}
N 70 -9030 130 -9030 {
lab=WL1}
N 70 -9050 130 -9050 {
lab=WL2}
N 70 -9070 130 -9070 {
lab=WL3}
N 70 -9090 130 -9090 {
lab=WL4}
N 70 -9110 130 -9110 {
lab=WL5}
N 70 -9130 130 -9130 {
lab=WL6}
N 70 -9150 130 -9150 {
lab=WL7}
N 70 -9170 130 -9170 {
lab=WL8}
N 70 -9190 130 -9190 {
lab=WL9}
N 70 -9210 130 -9210 {
lab=WL10}
N 70 -9230 130 -9230 {
lab=WL11}
N 70 -9250 130 -9250 {
lab=WL12}
N 70 -9270 130 -9270 {
lab=WL13}
N 70 -9290 130 -9290 {
lab=WL14}
N 70 -9310 130 -9310 {
lab=WL15}
N 60 -9300 60 -9000 {bus=true
lab=WL[0..15]}
N 60 -9000 60 -8970 {bus=true
lab=WL[0..15]}
N 910 -9010 970 -9010 {
lab=WL0}
N 910 -9030 970 -9030 {
lab=WL1}
N 910 -9050 970 -9050 {
lab=WL2}
N 910 -9070 970 -9070 {
lab=WL3}
N 910 -9090 970 -9090 {
lab=WL4}
N 910 -9110 970 -9110 {
lab=WL5}
N 910 -9130 970 -9130 {
lab=WL6}
N 910 -9150 970 -9150 {
lab=WL7}
N 910 -9170 970 -9170 {
lab=WL8}
N 910 -9190 970 -9190 {
lab=WL9}
N 910 -9210 970 -9210 {
lab=WL10}
N 910 -9230 970 -9230 {
lab=WL11}
N 910 -9250 970 -9250 {
lab=WL12}
N 910 -9270 970 -9270 {
lab=WL13}
N 910 -9290 970 -9290 {
lab=WL14}
N 910 -9310 970 -9310 {
lab=WL15}
N 850 -9010 910 -9010 {
lab=WL0}
N 850 -9030 910 -9030 {
lab=WL1}
N 850 -9050 910 -9050 {
lab=WL2}
N 850 -9070 910 -9070 {
lab=WL3}
N 850 -9090 910 -9090 {
lab=WL4}
N 850 -9110 910 -9110 {
lab=WL5}
N 850 -9130 910 -9130 {
lab=WL6}
N 850 -9150 910 -9150 {
lab=WL7}
N 850 -9170 910 -9170 {
lab=WL8}
N 850 -9190 910 -9190 {
lab=WL9}
N 850 -9210 910 -9210 {
lab=WL10}
N 850 -9230 910 -9230 {
lab=WL11}
N 850 -9250 910 -9250 {
lab=WL12}
N 850 -9270 910 -9270 {
lab=WL13}
N 850 -9290 910 -9290 {
lab=WL14}
N 850 -9310 910 -9310 {
lab=WL15}
N 790 -9010 850 -9010 {
lab=WL0}
N 790 -9030 850 -9030 {
lab=WL1}
N 790 -9050 850 -9050 {
lab=WL2}
N 790 -9070 850 -9070 {
lab=WL3}
N 790 -9090 850 -9090 {
lab=WL4}
N 790 -9110 850 -9110 {
lab=WL5}
N 790 -9130 850 -9130 {
lab=WL6}
N 790 -9150 850 -9150 {
lab=WL7}
N 790 -9170 850 -9170 {
lab=WL8}
N 790 -9190 850 -9190 {
lab=WL9}
N 790 -9210 850 -9210 {
lab=WL10}
N 790 -9230 850 -9230 {
lab=WL11}
N 790 -9250 850 -9250 {
lab=WL12}
N 790 -9270 850 -9270 {
lab=WL13}
N 790 -9290 850 -9290 {
lab=WL14}
N 790 -9310 850 -9310 {
lab=WL15}
N 780 -9300 780 -9000 {bus=true
lab=WL[0..15]}
N 780 -9000 780 -8970 {bus=true
lab=WL[0..15]}
N 1610 -9000 1670 -9000 {
lab=WL0}
N 1610 -9020 1670 -9020 {
lab=WL1}
N 1610 -9040 1670 -9040 {
lab=WL2}
N 1610 -9060 1670 -9060 {
lab=WL3}
N 1610 -9080 1670 -9080 {
lab=WL4}
N 1610 -9100 1670 -9100 {
lab=WL5}
N 1610 -9120 1670 -9120 {
lab=WL6}
N 1610 -9140 1670 -9140 {
lab=WL7}
N 1610 -9160 1670 -9160 {
lab=WL8}
N 1610 -9180 1670 -9180 {
lab=WL9}
N 1610 -9200 1670 -9200 {
lab=WL10}
N 1610 -9220 1670 -9220 {
lab=WL11}
N 1610 -9240 1670 -9240 {
lab=WL12}
N 1610 -9260 1670 -9260 {
lab=WL13}
N 1610 -9280 1670 -9280 {
lab=WL14}
N 1610 -9300 1670 -9300 {
lab=WL15}
N 1550 -9000 1610 -9000 {
lab=WL0}
N 1550 -9020 1610 -9020 {
lab=WL1}
N 1550 -9040 1610 -9040 {
lab=WL2}
N 1550 -9060 1610 -9060 {
lab=WL3}
N 1550 -9080 1610 -9080 {
lab=WL4}
N 1550 -9100 1610 -9100 {
lab=WL5}
N 1550 -9120 1610 -9120 {
lab=WL6}
N 1550 -9140 1610 -9140 {
lab=WL7}
N 1550 -9160 1610 -9160 {
lab=WL8}
N 1550 -9180 1610 -9180 {
lab=WL9}
N 1550 -9200 1610 -9200 {
lab=WL10}
N 1550 -9220 1610 -9220 {
lab=WL11}
N 1550 -9240 1610 -9240 {
lab=WL12}
N 1550 -9260 1610 -9260 {
lab=WL13}
N 1550 -9280 1610 -9280 {
lab=WL14}
N 1550 -9300 1610 -9300 {
lab=WL15}
N 1490 -9000 1550 -9000 {
lab=WL0}
N 1490 -9020 1550 -9020 {
lab=WL1}
N 1490 -9040 1550 -9040 {
lab=WL2}
N 1490 -9060 1550 -9060 {
lab=WL3}
N 1490 -9080 1550 -9080 {
lab=WL4}
N 1490 -9100 1550 -9100 {
lab=WL5}
N 1490 -9120 1550 -9120 {
lab=WL6}
N 1490 -9140 1550 -9140 {
lab=WL7}
N 1490 -9160 1550 -9160 {
lab=WL8}
N 1490 -9180 1550 -9180 {
lab=WL9}
N 1490 -9200 1550 -9200 {
lab=WL10}
N 1490 -9220 1550 -9220 {
lab=WL11}
N 1490 -9240 1550 -9240 {
lab=WL12}
N 1490 -9260 1550 -9260 {
lab=WL13}
N 1490 -9280 1550 -9280 {
lab=WL14}
N 1490 -9300 1550 -9300 {
lab=WL15}
N 1480 -9290 1480 -8990 {bus=true
lab=WL[0..15]}
N 1480 -8990 1480 -8960 {bus=true
lab=WL[0..15]}
N 2340 -9010 2400 -9010 {
lab=WL0}
N 2340 -9030 2400 -9030 {
lab=WL1}
N 2340 -9050 2400 -9050 {
lab=WL2}
N 2340 -9070 2400 -9070 {
lab=WL3}
N 2340 -9090 2400 -9090 {
lab=WL4}
N 2340 -9110 2400 -9110 {
lab=WL5}
N 2340 -9130 2400 -9130 {
lab=WL6}
N 2340 -9150 2400 -9150 {
lab=WL7}
N 2340 -9170 2400 -9170 {
lab=WL8}
N 2340 -9190 2400 -9190 {
lab=WL9}
N 2340 -9210 2400 -9210 {
lab=WL10}
N 2340 -9230 2400 -9230 {
lab=WL11}
N 2340 -9250 2400 -9250 {
lab=WL12}
N 2340 -9270 2400 -9270 {
lab=WL13}
N 2340 -9290 2400 -9290 {
lab=WL14}
N 2340 -9310 2400 -9310 {
lab=WL15}
N 2280 -9010 2340 -9010 {
lab=WL0}
N 2280 -9030 2340 -9030 {
lab=WL1}
N 2280 -9050 2340 -9050 {
lab=WL2}
N 2280 -9070 2340 -9070 {
lab=WL3}
N 2280 -9090 2340 -9090 {
lab=WL4}
N 2280 -9110 2340 -9110 {
lab=WL5}
N 2280 -9130 2340 -9130 {
lab=WL6}
N 2280 -9150 2340 -9150 {
lab=WL7}
N 2280 -9170 2340 -9170 {
lab=WL8}
N 2280 -9190 2340 -9190 {
lab=WL9}
N 2280 -9210 2340 -9210 {
lab=WL10}
N 2280 -9230 2340 -9230 {
lab=WL11}
N 2280 -9250 2340 -9250 {
lab=WL12}
N 2280 -9270 2340 -9270 {
lab=WL13}
N 2280 -9290 2340 -9290 {
lab=WL14}
N 2280 -9310 2340 -9310 {
lab=WL15}
N 2220 -9010 2280 -9010 {
lab=WL0}
N 2220 -9030 2280 -9030 {
lab=WL1}
N 2220 -9050 2280 -9050 {
lab=WL2}
N 2220 -9070 2280 -9070 {
lab=WL3}
N 2220 -9090 2280 -9090 {
lab=WL4}
N 2220 -9110 2280 -9110 {
lab=WL5}
N 2220 -9130 2280 -9130 {
lab=WL6}
N 2220 -9150 2280 -9150 {
lab=WL7}
N 2220 -9170 2280 -9170 {
lab=WL8}
N 2220 -9190 2280 -9190 {
lab=WL9}
N 2220 -9210 2280 -9210 {
lab=WL10}
N 2220 -9230 2280 -9230 {
lab=WL11}
N 2220 -9250 2280 -9250 {
lab=WL12}
N 2220 -9270 2280 -9270 {
lab=WL13}
N 2220 -9290 2280 -9290 {
lab=WL14}
N 2220 -9310 2280 -9310 {
lab=WL15}
N 2210 -9300 2210 -9000 {bus=true
lab=WL[0..15]}
N 2210 -9000 2210 -8970 {bus=true
lab=WL[0..15]}
N 3040 -9000 3100 -9000 {
lab=WL0}
N 3040 -9020 3100 -9020 {
lab=WL1}
N 3040 -9040 3100 -9040 {
lab=WL2}
N 3040 -9060 3100 -9060 {
lab=WL3}
N 3040 -9080 3100 -9080 {
lab=WL4}
N 3040 -9100 3100 -9100 {
lab=WL5}
N 3040 -9120 3100 -9120 {
lab=WL6}
N 3040 -9140 3100 -9140 {
lab=WL7}
N 3040 -9160 3100 -9160 {
lab=WL8}
N 3040 -9180 3100 -9180 {
lab=WL9}
N 3040 -9200 3100 -9200 {
lab=WL10}
N 3040 -9220 3100 -9220 {
lab=WL11}
N 3040 -9240 3100 -9240 {
lab=WL12}
N 3040 -9260 3100 -9260 {
lab=WL13}
N 3040 -9280 3100 -9280 {
lab=WL14}
N 3040 -9300 3100 -9300 {
lab=WL15}
N 2980 -9000 3040 -9000 {
lab=WL0}
N 2980 -9020 3040 -9020 {
lab=WL1}
N 2980 -9040 3040 -9040 {
lab=WL2}
N 2980 -9060 3040 -9060 {
lab=WL3}
N 2980 -9080 3040 -9080 {
lab=WL4}
N 2980 -9100 3040 -9100 {
lab=WL5}
N 2980 -9120 3040 -9120 {
lab=WL6}
N 2980 -9140 3040 -9140 {
lab=WL7}
N 2980 -9160 3040 -9160 {
lab=WL8}
N 2980 -9180 3040 -9180 {
lab=WL9}
N 2980 -9200 3040 -9200 {
lab=WL10}
N 2980 -9220 3040 -9220 {
lab=WL11}
N 2980 -9240 3040 -9240 {
lab=WL12}
N 2980 -9260 3040 -9260 {
lab=WL13}
N 2980 -9280 3040 -9280 {
lab=WL14}
N 2980 -9300 3040 -9300 {
lab=WL15}
N 2920 -9000 2980 -9000 {
lab=WL0}
N 2920 -9020 2980 -9020 {
lab=WL1}
N 2920 -9040 2980 -9040 {
lab=WL2}
N 2920 -9060 2980 -9060 {
lab=WL3}
N 2920 -9080 2980 -9080 {
lab=WL4}
N 2920 -9100 2980 -9100 {
lab=WL5}
N 2920 -9120 2980 -9120 {
lab=WL6}
N 2920 -9140 2980 -9140 {
lab=WL7}
N 2920 -9160 2980 -9160 {
lab=WL8}
N 2920 -9180 2980 -9180 {
lab=WL9}
N 2920 -9200 2980 -9200 {
lab=WL10}
N 2920 -9220 2980 -9220 {
lab=WL11}
N 2920 -9240 2980 -9240 {
lab=WL12}
N 2920 -9260 2980 -9260 {
lab=WL13}
N 2920 -9280 2980 -9280 {
lab=WL14}
N 2920 -9300 2980 -9300 {
lab=WL15}
N 2910 -9290 2910 -8990 {bus=true
lab=WL[0..15]}
N 2910 -8990 2910 -8960 {bus=true
lab=WL[0..15]}
N 3750 -9000 3810 -9000 {
lab=WL0}
N 3750 -9020 3810 -9020 {
lab=WL1}
N 3750 -9040 3810 -9040 {
lab=WL2}
N 3750 -9060 3810 -9060 {
lab=WL3}
N 3750 -9080 3810 -9080 {
lab=WL4}
N 3750 -9100 3810 -9100 {
lab=WL5}
N 3750 -9120 3810 -9120 {
lab=WL6}
N 3750 -9140 3810 -9140 {
lab=WL7}
N 3750 -9160 3810 -9160 {
lab=WL8}
N 3750 -9180 3810 -9180 {
lab=WL9}
N 3750 -9200 3810 -9200 {
lab=WL10}
N 3750 -9220 3810 -9220 {
lab=WL11}
N 3750 -9240 3810 -9240 {
lab=WL12}
N 3750 -9260 3810 -9260 {
lab=WL13}
N 3750 -9280 3810 -9280 {
lab=WL14}
N 3750 -9300 3810 -9300 {
lab=WL15}
N 3690 -9000 3750 -9000 {
lab=WL0}
N 3690 -9020 3750 -9020 {
lab=WL1}
N 3690 -9040 3750 -9040 {
lab=WL2}
N 3690 -9060 3750 -9060 {
lab=WL3}
N 3690 -9080 3750 -9080 {
lab=WL4}
N 3690 -9100 3750 -9100 {
lab=WL5}
N 3690 -9120 3750 -9120 {
lab=WL6}
N 3690 -9140 3750 -9140 {
lab=WL7}
N 3690 -9160 3750 -9160 {
lab=WL8}
N 3690 -9180 3750 -9180 {
lab=WL9}
N 3690 -9200 3750 -9200 {
lab=WL10}
N 3690 -9220 3750 -9220 {
lab=WL11}
N 3690 -9240 3750 -9240 {
lab=WL12}
N 3690 -9260 3750 -9260 {
lab=WL13}
N 3690 -9280 3750 -9280 {
lab=WL14}
N 3690 -9300 3750 -9300 {
lab=WL15}
N 3630 -9000 3690 -9000 {
lab=WL0}
N 3630 -9020 3690 -9020 {
lab=WL1}
N 3630 -9040 3690 -9040 {
lab=WL2}
N 3630 -9060 3690 -9060 {
lab=WL3}
N 3630 -9080 3690 -9080 {
lab=WL4}
N 3630 -9100 3690 -9100 {
lab=WL5}
N 3630 -9120 3690 -9120 {
lab=WL6}
N 3630 -9140 3690 -9140 {
lab=WL7}
N 3630 -9160 3690 -9160 {
lab=WL8}
N 3630 -9180 3690 -9180 {
lab=WL9}
N 3630 -9200 3690 -9200 {
lab=WL10}
N 3630 -9220 3690 -9220 {
lab=WL11}
N 3630 -9240 3690 -9240 {
lab=WL12}
N 3630 -9260 3690 -9260 {
lab=WL13}
N 3630 -9280 3690 -9280 {
lab=WL14}
N 3630 -9300 3690 -9300 {
lab=WL15}
N 3620 -9290 3620 -8990 {bus=true
lab=WL[0..15]}
N 3620 -8990 3620 -8960 {bus=true
lab=WL[0..15]}
N 40 -9350 190 -9350 {
lab=rA0}
N 40 -9390 190 -9390 {
lab=rA2}
N 40 -9410 190 -9410 {
lab=rA3}
N 40 -9430 190 -9430 {
lab=rA4}
N 40 -9450 190 -9450 {
lab=rA5}
N 40 -9470 190 -9470 {
lab=rA6}
N 40 -9490 190 -9490 {
lab=rA7}
N 40 -9510 190 -9510 {
lab=rA8}
N 40 -9550 190 -9550 {
lab=rA10}
N 40 -9530 190 -9530 {
lab=rA9}
N 40 -9570 190 -9570 {
lab=rA11}
N 40 -9590 190 -9590 {
lab=rA12}
N 40 -9610 190 -9610 {
lab=rA13}
N 40 -9630 190 -9630 {
lab=rA14}
N 40 -9650 190 -9650 {
lab=rA15}
N 190 -9850 250 -9850 {
lab=SAMPLE}
N 190 -9830 250 -9830 {
lab=Vrminus}
N 190 -9810 250 -9810 {
lab=Vrplus}
N 40 -9370 190 -9370 {
lab=rA1}
N 190 -9370 250 -9370 {
lab=rA1}
N 190 -9390 250 -9390 {
lab=rA2}
N 190 -9410 250 -9410 {
lab=rA3}
N 190 -9430 250 -9430 {
lab=rA4}
N 190 -9450 250 -9450 {
lab=rA5}
N 190 -9470 250 -9470 {
lab=rA6}
N 190 -9490 250 -9490 {
lab=rA7}
N 190 -9510 250 -9510 {
lab=rA8}
N 190 -9530 250 -9530 {
lab=rA9}
N 190 -9550 250 -9550 {
lab=rA10}
N 190 -9570 250 -9570 {
lab=rA11}
N 190 -9590 250 -9590 {
lab=rA12}
N 190 -9610 250 -9610 {
lab=rA13}
N 190 -9630 250 -9630 {
lab=rA14}
N 190 -9650 250 -9650 {
lab=rA15}
N 30 -9640 30 -9300 {
lab=rA[0..15]
bus=true}
N 550 -9350 600 -9350 {
lab=rB0}
N 550 -9370 600 -9370 {
lab=rB1}
N 670 -9360 670 -9300 {
lab=rB[0..15]
bus=true}
N 550 -9390 600 -9390 {
lab=rB2}
N 550 -9410 600 -9410 {
lab=rB3}
N 550 -9430 600 -9430 {
lab=rB4}
N 550 -9450 600 -9450 {
lab=rB5}
N 550 -9470 600 -9470 {
lab=rB6}
N 550 -9490 600 -9490 {
lab=rB7}
N 550 -9510 600 -9510 {
lab=rB8}
N 550 -9530 600 -9530 {
lab=rB9}
N 550 -9550 600 -9550 {
lab=rB10}
N 550 -9570 600 -9570 {
lab=rB11}
N 550 -9590 600 -9590 {
lab=rB12}
N 550 -9610 600 -9610 {
lab=rB13}
N 550 -9630 600 -9630 {
lab=rB14}
N 550 -9650 600 -9650 {
lab=rB15}
N 670 -9640 670 -9360 {
lab=rB[0..15]
bus=true}
N 180 -8960 180 -8660 {bus=true
lab=cA[0..15]}
N 180 -8660 180 -8630 {bus=true
lab=cA[0..15]}
N 550 -8670 610 -8670 {
lab=cB0}
N 550 -8690 610 -8690 {
lab=cB1}
N 550 -8710 610 -8710 {
lab=cB2}
N 550 -8730 610 -8730 {
lab=cB3}
N 550 -8750 610 -8750 {
lab=cB4}
N 550 -8770 610 -8770 {
lab=cB5}
N 550 -8790 610 -8790 {
lab=cB6}
N 550 -8810 610 -8810 {
lab=cB7}
N 550 -8830 610 -8830 {
lab=cB8}
N 550 -8850 610 -8850 {
lab=cB9}
N 550 -8870 610 -8870 {
lab=cB10}
N 550 -8890 610 -8890 {
lab=cB11}
N 550 -8910 610 -8910 {
lab=cB12}
N 550 -8930 610 -8930 {
lab=cB13}
N 550 -8950 610 -8950 {
lab=cB14}
N 550 -8970 610 -8970 {
lab=cB15}
N 620 -8960 620 -8660 {bus=true
lab=cB[0..15]}
N 620 -8660 620 -8630 {bus=true
lab=cB[0..15]}
N 910 -9350 970 -9350 {
lab=rA0}
N 1320 -9350 1380 -9350 {
lab=rB0}
N 1320 -9370 1380 -9370 {
lab=rB1}
N 1320 -9390 1380 -9390 {
lab=rB2}
N 1320 -9410 1380 -9410 {
lab=rB3}
N 1320 -9430 1380 -9430 {
lab=rB4}
N 1320 -9450 1380 -9450 {
lab=rB5}
N 1320 -9470 1380 -9470 {
lab=rB6}
N 1320 -9490 1380 -9490 {
lab=rB7}
N 1320 -9510 1380 -9510 {
lab=rB8}
N 1320 -9530 1380 -9530 {
lab=rB9}
N 1320 -9550 1380 -9550 {
lab=rB10}
N 1320 -9570 1380 -9570 {
lab=rB11}
N 1320 -9590 1380 -9590 {
lab=rB12}
N 1320 -9610 1380 -9610 {
lab=rB13}
N 1320 -9630 1380 -9630 {
lab=rB14}
N 1320 -9650 1380 -9650 {
lab=rB15}
N 910 -9930 970 -9930 {
lab=col1_sel}
N 910 -9950 970 -9950 {
lab=row4_sel}
N 910 -9710 970 -9710 {
lab=Vcplus}
N 910 -9730 970 -9730 {
lab=Vcminus}
N 910 -9750 970 -9750 {
lab=Vref}
N 910 -9770 970 -9770 {
lab=Vref_comp}
N 910 -9790 970 -9790 {
lab=RISC_CLK}
N 1270 -9890 1330 -9890 {
lab=vssd1}
N 1270 -9910 1330 -9910 {
lab=vdda1}
N 1270 -9930 1330 -9930 {
lab=vccd1}
N 1270 -9950 1330 -9950 {
lab=latch_high1}
N 760 -9350 910 -9350 {
lab=rA0}
N 760 -9390 910 -9390 {
lab=rA2}
N 760 -9410 910 -9410 {
lab=rA3}
N 760 -9430 910 -9430 {
lab=rA4}
N 760 -9450 910 -9450 {
lab=rA5}
N 760 -9470 910 -9470 {
lab=rA6}
N 760 -9490 910 -9490 {
lab=rA7}
N 760 -9510 910 -9510 {
lab=rA8}
N 760 -9550 910 -9550 {
lab=rA10}
N 760 -9530 910 -9530 {
lab=rA9}
N 760 -9570 910 -9570 {
lab=rA11}
N 760 -9590 910 -9590 {
lab=rA12}
N 760 -9610 910 -9610 {
lab=rA13}
N 760 -9630 910 -9630 {
lab=rA14}
N 760 -9650 910 -9650 {
lab=rA15}
N 910 -9850 970 -9850 {
lab=SAMPLE}
N 910 -9830 970 -9830 {
lab=Vrminus}
N 910 -9810 970 -9810 {
lab=Vrplus}
N 760 -9370 910 -9370 {
lab=rA1}
N 910 -9370 970 -9370 {
lab=rA1}
N 910 -9390 970 -9390 {
lab=rA2}
N 910 -9410 970 -9410 {
lab=rA3}
N 910 -9430 970 -9430 {
lab=rA4}
N 910 -9450 970 -9450 {
lab=rA5}
N 910 -9470 970 -9470 {
lab=rA6}
N 910 -9490 970 -9490 {
lab=rA7}
N 910 -9510 970 -9510 {
lab=rA8}
N 910 -9530 970 -9530 {
lab=rA9}
N 910 -9550 970 -9550 {
lab=rA10}
N 910 -9570 970 -9570 {
lab=rA11}
N 910 -9590 970 -9590 {
lab=rA12}
N 910 -9610 970 -9610 {
lab=rA13}
N 910 -9630 970 -9630 {
lab=rA14}
N 910 -9650 970 -9650 {
lab=rA15}
N 750 -9640 750 -9300 {
lab=rA[0..15]
bus=true}
N 1270 -9350 1320 -9350 {
lab=rB0}
N 1270 -9370 1320 -9370 {
lab=rB1}
N 1390 -9360 1390 -9300 {
lab=rB[0..15]
bus=true}
N 1270 -9390 1320 -9390 {
lab=rB2}
N 1270 -9410 1320 -9410 {
lab=rB3}
N 1270 -9430 1320 -9430 {
lab=rB4}
N 1270 -9450 1320 -9450 {
lab=rB5}
N 1270 -9470 1320 -9470 {
lab=rB6}
N 1270 -9490 1320 -9490 {
lab=rB7}
N 1270 -9510 1320 -9510 {
lab=rB8}
N 1270 -9530 1320 -9530 {
lab=rB9}
N 1270 -9550 1320 -9550 {
lab=rB10}
N 1270 -9570 1320 -9570 {
lab=rB11}
N 1270 -9590 1320 -9590 {
lab=rB12}
N 1270 -9610 1320 -9610 {
lab=rB13}
N 1270 -9630 1320 -9630 {
lab=rB14}
N 1270 -9650 1320 -9650 {
lab=rB15}
N 1390 -9640 1390 -9360 {
lab=rB[0..15]
bus=true}
N 910 -9890 970 -9890 {
lab=WR}
N 910 -9910 970 -9910 {
lab=Vgnr}
N 910 -9870 970 -9870 {
lab=Vgpr}
N 1610 -9920 1670 -9920 {
lab=col2_sel}
N 1610 -9940 1670 -9940 {
lab=row4_sel}
N 1610 -9700 1670 -9700 {
lab=Vcplus}
N 1610 -9720 1670 -9720 {
lab=Vcminus}
N 1610 -9740 1670 -9740 {
lab=Vref}
N 1610 -9760 1670 -9760 {
lab=Vref_comp}
N 1610 -9780 1670 -9780 {
lab=RISC_CLK}
N 1610 -9840 1670 -9840 {
lab=SAMPLE}
N 1610 -9820 1670 -9820 {
lab=Vrminus}
N 1610 -9800 1670 -9800 {
lab=Vrplus}
N 1610 -9880 1670 -9880 {
lab=WR}
N 1610 -9900 1670 -9900 {
lab=Vgnr}
N 1610 -9860 1670 -9860 {
lab=Vgpr}
N 1970 -9880 2030 -9880 {
lab=vssd1}
N 1970 -9900 2030 -9900 {
lab=vdda1}
N 1970 -9920 2030 -9920 {
lab=vccd1}
N 1610 -9340 1670 -9340 {
lab=rA0}
N 2020 -9340 2080 -9340 {
lab=rB0}
N 2020 -9360 2080 -9360 {
lab=rB1}
N 2020 -9380 2080 -9380 {
lab=rB2}
N 2020 -9400 2080 -9400 {
lab=rB3}
N 2020 -9420 2080 -9420 {
lab=rB4}
N 2020 -9440 2080 -9440 {
lab=rB5}
N 2020 -9460 2080 -9460 {
lab=rB6}
N 2020 -9480 2080 -9480 {
lab=rB7}
N 2020 -9500 2080 -9500 {
lab=rB8}
N 2020 -9520 2080 -9520 {
lab=rB9}
N 2020 -9540 2080 -9540 {
lab=rB10}
N 2020 -9560 2080 -9560 {
lab=rB11}
N 2020 -9580 2080 -9580 {
lab=rB12}
N 2020 -9600 2080 -9600 {
lab=rB13}
N 2020 -9620 2080 -9620 {
lab=rB14}
N 2020 -9640 2080 -9640 {
lab=rB15}
N 1460 -9340 1610 -9340 {
lab=rA0}
N 1460 -9380 1610 -9380 {
lab=rA2}
N 1460 -9400 1610 -9400 {
lab=rA3}
N 1460 -9420 1610 -9420 {
lab=rA4}
N 1460 -9440 1610 -9440 {
lab=rA5}
N 1460 -9460 1610 -9460 {
lab=rA6}
N 1460 -9480 1610 -9480 {
lab=rA7}
N 1460 -9500 1610 -9500 {
lab=rA8}
N 1460 -9540 1610 -9540 {
lab=rA10}
N 1460 -9520 1610 -9520 {
lab=rA9}
N 1460 -9560 1610 -9560 {
lab=rA11}
N 1460 -9580 1610 -9580 {
lab=rA12}
N 1460 -9600 1610 -9600 {
lab=rA13}
N 1460 -9620 1610 -9620 {
lab=rA14}
N 1460 -9640 1610 -9640 {
lab=rA15}
N 1460 -9360 1610 -9360 {
lab=rA1}
N 1610 -9360 1670 -9360 {
lab=rA1}
N 1610 -9380 1670 -9380 {
lab=rA2}
N 1610 -9400 1670 -9400 {
lab=rA3}
N 1610 -9420 1670 -9420 {
lab=rA4}
N 1610 -9440 1670 -9440 {
lab=rA5}
N 1610 -9460 1670 -9460 {
lab=rA6}
N 1610 -9480 1670 -9480 {
lab=rA7}
N 1610 -9500 1670 -9500 {
lab=rA8}
N 1610 -9520 1670 -9520 {
lab=rA9}
N 1610 -9540 1670 -9540 {
lab=rA10}
N 1610 -9560 1670 -9560 {
lab=rA11}
N 1610 -9580 1670 -9580 {
lab=rA12}
N 1610 -9600 1670 -9600 {
lab=rA13}
N 1610 -9620 1670 -9620 {
lab=rA14}
N 1610 -9640 1670 -9640 {
lab=rA15}
N 1450 -9630 1450 -9290 {
lab=rA[0..15]
bus=true}
N 1970 -9340 2020 -9340 {
lab=rB0}
N 1970 -9360 2020 -9360 {
lab=rB1}
N 2090 -9350 2090 -9290 {
lab=rB[0..15]
bus=true}
N 1970 -9380 2020 -9380 {
lab=rB2}
N 1970 -9400 2020 -9400 {
lab=rB3}
N 1970 -9420 2020 -9420 {
lab=rB4}
N 1970 -9440 2020 -9440 {
lab=rB5}
N 1970 -9460 2020 -9460 {
lab=rB6}
N 1970 -9480 2020 -9480 {
lab=rB7}
N 1970 -9500 2020 -9500 {
lab=rB8}
N 1970 -9520 2020 -9520 {
lab=rB9}
N 1970 -9540 2020 -9540 {
lab=rB10}
N 1970 -9560 2020 -9560 {
lab=rB11}
N 1970 -9580 2020 -9580 {
lab=rB12}
N 1970 -9600 2020 -9600 {
lab=rB13}
N 1970 -9620 2020 -9620 {
lab=rB14}
N 1970 -9640 2020 -9640 {
lab=rB15}
N 2090 -9630 2090 -9350 {
lab=rB[0..15]
bus=true}
N 910 -8670 970 -8670 {
lab=cA0}
N 910 -8690 970 -8690 {
lab=cA1}
N 910 -8710 970 -8710 {
lab=cA2}
N 910 -8730 970 -8730 {
lab=cA3}
N 910 -8750 970 -8750 {
lab=cA4}
N 910 -8770 970 -8770 {
lab=cA5}
N 910 -8790 970 -8790 {
lab=cA6}
N 910 -8810 970 -8810 {
lab=cA7}
N 910 -8830 970 -8830 {
lab=cA8}
N 910 -8850 970 -8850 {
lab=cA9}
N 910 -8870 970 -8870 {
lab=cA10}
N 910 -8890 970 -8890 {
lab=cA11}
N 910 -8910 970 -8910 {
lab=cA12}
N 910 -8930 970 -8930 {
lab=cA13}
N 910 -8950 970 -8950 {
lab=cA14}
N 910 -8970 970 -8970 {
lab=cA15}
N 900 -8960 900 -8660 {bus=true
lab=cA[0..15]}
N 900 -8660 900 -8630 {bus=true
lab=cA[0..15]}
N 1270 -8670 1330 -8670 {
lab=cB0}
N 1270 -8690 1330 -8690 {
lab=cB1}
N 1270 -8710 1330 -8710 {
lab=cB2}
N 1270 -8730 1330 -8730 {
lab=cB3}
N 1270 -8750 1330 -8750 {
lab=cB4}
N 1270 -8770 1330 -8770 {
lab=cB5}
N 1270 -8790 1330 -8790 {
lab=cB6}
N 1270 -8810 1330 -8810 {
lab=cB7}
N 1270 -8830 1330 -8830 {
lab=cB8}
N 1270 -8850 1330 -8850 {
lab=cB9}
N 1270 -8870 1330 -8870 {
lab=cB10}
N 1270 -8890 1330 -8890 {
lab=cB11}
N 1270 -8910 1330 -8910 {
lab=cB12}
N 1270 -8930 1330 -8930 {
lab=cB13}
N 1270 -8950 1330 -8950 {
lab=cB14}
N 1270 -8970 1330 -8970 {
lab=cB15}
N 1340 -8960 1340 -8660 {bus=true
lab=cB[0..15]}
N 1340 -8660 1340 -8630 {bus=true
lab=cB[0..15]}
N 1610 -8660 1670 -8660 {
lab=cA0}
N 1610 -8680 1670 -8680 {
lab=cA1}
N 1610 -8700 1670 -8700 {
lab=cA2}
N 1610 -8720 1670 -8720 {
lab=cA3}
N 1610 -8740 1670 -8740 {
lab=cA4}
N 1610 -8760 1670 -8760 {
lab=cA5}
N 1610 -8780 1670 -8780 {
lab=cA6}
N 1610 -8800 1670 -8800 {
lab=cA7}
N 1610 -8820 1670 -8820 {
lab=cA8}
N 1610 -8840 1670 -8840 {
lab=cA9}
N 1610 -8860 1670 -8860 {
lab=cA10}
N 1610 -8880 1670 -8880 {
lab=cA11}
N 1610 -8900 1670 -8900 {
lab=cA12}
N 1610 -8920 1670 -8920 {
lab=cA13}
N 1610 -8940 1670 -8940 {
lab=cA14}
N 1610 -8960 1670 -8960 {
lab=cA15}
N 1600 -8950 1600 -8650 {bus=true
lab=cA[0..15]}
N 1600 -8650 1600 -8620 {bus=true
lab=cA[0..15]}
N 1970 -8660 2030 -8660 {
lab=cB0}
N 1970 -8680 2030 -8680 {
lab=cB1}
N 1970 -8700 2030 -8700 {
lab=cB2}
N 1970 -8720 2030 -8720 {
lab=cB3}
N 1970 -8740 2030 -8740 {
lab=cB4}
N 1970 -8760 2030 -8760 {
lab=cB5}
N 1970 -8780 2030 -8780 {
lab=cB6}
N 1970 -8800 2030 -8800 {
lab=cB7}
N 1970 -8820 2030 -8820 {
lab=cB8}
N 1970 -8840 2030 -8840 {
lab=cB9}
N 1970 -8860 2030 -8860 {
lab=cB10}
N 1970 -8880 2030 -8880 {
lab=cB11}
N 1970 -8900 2030 -8900 {
lab=cB12}
N 1970 -8920 2030 -8920 {
lab=cB13}
N 1970 -8940 2030 -8940 {
lab=cB14}
N 1970 -8960 2030 -8960 {
lab=cB15}
N 2040 -8950 2040 -8650 {bus=true
lab=cB[0..15]}
N 2040 -8650 2040 -8620 {bus=true
lab=cB[0..15]}
N 2340 -9350 2400 -9350 {
lab=rA0}
N 2750 -9350 2810 -9350 {
lab=rB0}
N 2750 -9370 2810 -9370 {
lab=rB1}
N 2750 -9390 2810 -9390 {
lab=rB2}
N 2750 -9410 2810 -9410 {
lab=rB3}
N 2750 -9430 2810 -9430 {
lab=rB4}
N 2750 -9450 2810 -9450 {
lab=rB5}
N 2750 -9470 2810 -9470 {
lab=rB6}
N 2750 -9490 2810 -9490 {
lab=rB7}
N 2750 -9510 2810 -9510 {
lab=rB8}
N 2750 -9530 2810 -9530 {
lab=rB9}
N 2750 -9550 2810 -9550 {
lab=rB10}
N 2750 -9570 2810 -9570 {
lab=rB11}
N 2750 -9590 2810 -9590 {
lab=rB12}
N 2750 -9610 2810 -9610 {
lab=rB13}
N 2750 -9630 2810 -9630 {
lab=rB14}
N 2750 -9650 2810 -9650 {
lab=rB15}
N 2190 -9350 2340 -9350 {
lab=rA0}
N 2190 -9390 2340 -9390 {
lab=rA2}
N 2190 -9410 2340 -9410 {
lab=rA3}
N 2190 -9430 2340 -9430 {
lab=rA4}
N 2190 -9450 2340 -9450 {
lab=rA5}
N 2190 -9470 2340 -9470 {
lab=rA6}
N 2190 -9490 2340 -9490 {
lab=rA7}
N 2190 -9510 2340 -9510 {
lab=rA8}
N 2190 -9550 2340 -9550 {
lab=rA10}
N 2190 -9530 2340 -9530 {
lab=rA9}
N 2190 -9570 2340 -9570 {
lab=rA11}
N 2190 -9590 2340 -9590 {
lab=rA12}
N 2190 -9610 2340 -9610 {
lab=rA13}
N 2190 -9630 2340 -9630 {
lab=rA14}
N 2190 -9650 2340 -9650 {
lab=rA15}
N 2190 -9370 2340 -9370 {
lab=rA1}
N 2340 -9370 2400 -9370 {
lab=rA1}
N 2340 -9390 2400 -9390 {
lab=rA2}
N 2340 -9410 2400 -9410 {
lab=rA3}
N 2340 -9430 2400 -9430 {
lab=rA4}
N 2340 -9450 2400 -9450 {
lab=rA5}
N 2340 -9470 2400 -9470 {
lab=rA6}
N 2340 -9490 2400 -9490 {
lab=rA7}
N 2340 -9510 2400 -9510 {
lab=rA8}
N 2340 -9530 2400 -9530 {
lab=rA9}
N 2340 -9550 2400 -9550 {
lab=rA10}
N 2340 -9570 2400 -9570 {
lab=rA11}
N 2340 -9590 2400 -9590 {
lab=rA12}
N 2340 -9610 2400 -9610 {
lab=rA13}
N 2340 -9630 2400 -9630 {
lab=rA14}
N 2340 -9650 2400 -9650 {
lab=rA15}
N 2180 -9640 2180 -9300 {
lab=rA[0..15]
bus=true}
N 2700 -9350 2750 -9350 {
lab=rB0}
N 2700 -9370 2750 -9370 {
lab=rB1}
N 2820 -9360 2820 -9300 {
lab=rB[0..15]
bus=true}
N 2700 -9390 2750 -9390 {
lab=rB2}
N 2700 -9410 2750 -9410 {
lab=rB3}
N 2700 -9430 2750 -9430 {
lab=rB4}
N 2700 -9450 2750 -9450 {
lab=rB5}
N 2700 -9470 2750 -9470 {
lab=rB6}
N 2700 -9490 2750 -9490 {
lab=rB7}
N 2700 -9510 2750 -9510 {
lab=rB8}
N 2700 -9530 2750 -9530 {
lab=rB9}
N 2700 -9550 2750 -9550 {
lab=rB10}
N 2700 -9570 2750 -9570 {
lab=rB11}
N 2700 -9590 2750 -9590 {
lab=rB12}
N 2700 -9610 2750 -9610 {
lab=rB13}
N 2700 -9630 2750 -9630 {
lab=rB14}
N 2700 -9650 2750 -9650 {
lab=rB15}
N 2820 -9640 2820 -9360 {
lab=rB[0..15]
bus=true}
N 2340 -8670 2400 -8670 {
lab=cA0}
N 2340 -8690 2400 -8690 {
lab=cA1}
N 2340 -8710 2400 -8710 {
lab=cA2}
N 2340 -8730 2400 -8730 {
lab=cA3}
N 2340 -8750 2400 -8750 {
lab=cA4}
N 2340 -8770 2400 -8770 {
lab=cA5}
N 2340 -8790 2400 -8790 {
lab=cA6}
N 2340 -8810 2400 -8810 {
lab=cA7}
N 2340 -8830 2400 -8830 {
lab=cA8}
N 2340 -8850 2400 -8850 {
lab=cA9}
N 2340 -8870 2400 -8870 {
lab=cA10}
N 2340 -8890 2400 -8890 {
lab=cA11}
N 2340 -8910 2400 -8910 {
lab=cA12}
N 2340 -8930 2400 -8930 {
lab=cA13}
N 2340 -8950 2400 -8950 {
lab=cA14}
N 2340 -8970 2400 -8970 {
lab=cA15}
N 2330 -8960 2330 -8660 {bus=true
lab=cA[0..15]}
N 2330 -8660 2330 -8630 {bus=true
lab=cA[0..15]}
N 2700 -8670 2760 -8670 {
lab=cB0}
N 2700 -8690 2760 -8690 {
lab=cB1}
N 2700 -8710 2760 -8710 {
lab=cB2}
N 2700 -8730 2760 -8730 {
lab=cB3}
N 2700 -8750 2760 -8750 {
lab=cB4}
N 2700 -8770 2760 -8770 {
lab=cB5}
N 2700 -8790 2760 -8790 {
lab=cB6}
N 2700 -8810 2760 -8810 {
lab=cB7}
N 2700 -8830 2760 -8830 {
lab=cB8}
N 2700 -8850 2760 -8850 {
lab=cB9}
N 2700 -8870 2760 -8870 {
lab=cB10}
N 2700 -8890 2760 -8890 {
lab=cB11}
N 2700 -8910 2760 -8910 {
lab=cB12}
N 2700 -8930 2760 -8930 {
lab=cB13}
N 2700 -8950 2760 -8950 {
lab=cB14}
N 2700 -8970 2760 -8970 {
lab=cB15}
N 2770 -8960 2770 -8660 {bus=true
lab=cB[0..15]}
N 2770 -8660 2770 -8630 {bus=true
lab=cB[0..15]}
N 3040 -9340 3100 -9340 {
lab=rA0}
N 3450 -9340 3510 -9340 {
lab=rB0}
N 3450 -9360 3510 -9360 {
lab=rB1}
N 3450 -9380 3510 -9380 {
lab=rB2}
N 3450 -9400 3510 -9400 {
lab=rB3}
N 3450 -9420 3510 -9420 {
lab=rB4}
N 3450 -9440 3510 -9440 {
lab=rB5}
N 3450 -9460 3510 -9460 {
lab=rB6}
N 3450 -9480 3510 -9480 {
lab=rB7}
N 3450 -9500 3510 -9500 {
lab=rB8}
N 3450 -9520 3510 -9520 {
lab=rB9}
N 3450 -9540 3510 -9540 {
lab=rB10}
N 3450 -9560 3510 -9560 {
lab=rB11}
N 3450 -9580 3510 -9580 {
lab=rB12}
N 3450 -9600 3510 -9600 {
lab=rB13}
N 3450 -9620 3510 -9620 {
lab=rB14}
N 3450 -9640 3510 -9640 {
lab=rB15}
N 2890 -9340 3040 -9340 {
lab=rA0}
N 2890 -9380 3040 -9380 {
lab=rA2}
N 2890 -9400 3040 -9400 {
lab=rA3}
N 2890 -9420 3040 -9420 {
lab=rA4}
N 2890 -9440 3040 -9440 {
lab=rA5}
N 2890 -9460 3040 -9460 {
lab=rA6}
N 2890 -9480 3040 -9480 {
lab=rA7}
N 2890 -9500 3040 -9500 {
lab=rA8}
N 2890 -9540 3040 -9540 {
lab=rA10}
N 2890 -9520 3040 -9520 {
lab=rA9}
N 2890 -9560 3040 -9560 {
lab=rA11}
N 2890 -9580 3040 -9580 {
lab=rA12}
N 2890 -9600 3040 -9600 {
lab=rA13}
N 2890 -9620 3040 -9620 {
lab=rA14}
N 2890 -9640 3040 -9640 {
lab=rA15}
N 2890 -9360 3040 -9360 {
lab=rA1}
N 3040 -9360 3100 -9360 {
lab=rA1}
N 3040 -9380 3100 -9380 {
lab=rA2}
N 3040 -9400 3100 -9400 {
lab=rA3}
N 3040 -9420 3100 -9420 {
lab=rA4}
N 3040 -9440 3100 -9440 {
lab=rA5}
N 3040 -9460 3100 -9460 {
lab=rA6}
N 3040 -9480 3100 -9480 {
lab=rA7}
N 3040 -9500 3100 -9500 {
lab=rA8}
N 3040 -9520 3100 -9520 {
lab=rA9}
N 3040 -9540 3100 -9540 {
lab=rA10}
N 3040 -9560 3100 -9560 {
lab=rA11}
N 3040 -9580 3100 -9580 {
lab=rA12}
N 3040 -9600 3100 -9600 {
lab=rA13}
N 3040 -9620 3100 -9620 {
lab=rA14}
N 3040 -9640 3100 -9640 {
lab=rA15}
N 2880 -9630 2880 -9290 {
lab=rA[0..15]
bus=true}
N 3400 -9340 3450 -9340 {
lab=rB0}
N 3400 -9360 3450 -9360 {
lab=rB1}
N 3520 -9350 3520 -9290 {
lab=rB[0..15]
bus=true}
N 3400 -9380 3450 -9380 {
lab=rB2}
N 3400 -9400 3450 -9400 {
lab=rB3}
N 3400 -9420 3450 -9420 {
lab=rB4}
N 3400 -9440 3450 -9440 {
lab=rB5}
N 3400 -9460 3450 -9460 {
lab=rB6}
N 3400 -9480 3450 -9480 {
lab=rB7}
N 3400 -9500 3450 -9500 {
lab=rB8}
N 3400 -9520 3450 -9520 {
lab=rB9}
N 3400 -9540 3450 -9540 {
lab=rB10}
N 3400 -9560 3450 -9560 {
lab=rB11}
N 3400 -9580 3450 -9580 {
lab=rB12}
N 3400 -9600 3450 -9600 {
lab=rB13}
N 3400 -9620 3450 -9620 {
lab=rB14}
N 3400 -9640 3450 -9640 {
lab=rB15}
N 3520 -9630 3520 -9350 {
lab=rB[0..15]
bus=true}
N 3040 -8660 3100 -8660 {
lab=cA0}
N 3040 -8680 3100 -8680 {
lab=cA1}
N 3040 -8700 3100 -8700 {
lab=cA2}
N 3040 -8720 3100 -8720 {
lab=cA3}
N 3040 -8740 3100 -8740 {
lab=cA4}
N 3040 -8760 3100 -8760 {
lab=cA5}
N 3040 -8780 3100 -8780 {
lab=cA6}
N 3040 -8800 3100 -8800 {
lab=cA7}
N 3040 -8820 3100 -8820 {
lab=cA8}
N 3040 -8840 3100 -8840 {
lab=cA9}
N 3040 -8860 3100 -8860 {
lab=cA10}
N 3040 -8880 3100 -8880 {
lab=cA11}
N 3040 -8900 3100 -8900 {
lab=cA12}
N 3040 -8920 3100 -8920 {
lab=cA13}
N 3040 -8940 3100 -8940 {
lab=cA14}
N 3040 -8960 3100 -8960 {
lab=cA15}
N 3030 -8950 3030 -8650 {bus=true
lab=cA[0..15]}
N 3030 -8650 3030 -8620 {bus=true
lab=cA[0..15]}
N 3400 -8660 3460 -8660 {
lab=cB0}
N 3400 -8680 3460 -8680 {
lab=cB1}
N 3400 -8700 3460 -8700 {
lab=cB2}
N 3400 -8720 3460 -8720 {
lab=cB3}
N 3400 -8740 3460 -8740 {
lab=cB4}
N 3400 -8760 3460 -8760 {
lab=cB5}
N 3400 -8780 3460 -8780 {
lab=cB6}
N 3400 -8800 3460 -8800 {
lab=cB7}
N 3400 -8820 3460 -8820 {
lab=cB8}
N 3400 -8840 3460 -8840 {
lab=cB9}
N 3400 -8860 3460 -8860 {
lab=cB10}
N 3400 -8880 3460 -8880 {
lab=cB11}
N 3400 -8900 3460 -8900 {
lab=cB12}
N 3400 -8920 3460 -8920 {
lab=cB13}
N 3400 -8940 3460 -8940 {
lab=cB14}
N 3400 -8960 3460 -8960 {
lab=cB15}
N 3470 -8950 3470 -8650 {bus=true
lab=cB[0..15]}
N 3470 -8650 3470 -8620 {bus=true
lab=cB[0..15]}
N 3750 -9340 3810 -9340 {
lab=rA0}
N 4160 -9340 4220 -9340 {
lab=rB0}
N 4160 -9360 4220 -9360 {
lab=rB1}
N 4160 -9380 4220 -9380 {
lab=rB2}
N 4160 -9400 4220 -9400 {
lab=rB3}
N 4160 -9420 4220 -9420 {
lab=rB4}
N 4160 -9440 4220 -9440 {
lab=rB5}
N 4160 -9460 4220 -9460 {
lab=rB6}
N 4160 -9480 4220 -9480 {
lab=rB7}
N 4160 -9500 4220 -9500 {
lab=rB8}
N 4160 -9520 4220 -9520 {
lab=rB9}
N 4160 -9540 4220 -9540 {
lab=rB10}
N 4160 -9560 4220 -9560 {
lab=rB11}
N 4160 -9580 4220 -9580 {
lab=rB12}
N 4160 -9600 4220 -9600 {
lab=rB13}
N 4160 -9620 4220 -9620 {
lab=rB14}
N 4160 -9640 4220 -9640 {
lab=rB15}
N 3600 -9340 3750 -9340 {
lab=rA0}
N 3600 -9380 3750 -9380 {
lab=rA2}
N 3600 -9400 3750 -9400 {
lab=rA3}
N 3600 -9420 3750 -9420 {
lab=rA4}
N 3600 -9440 3750 -9440 {
lab=rA5}
N 3600 -9460 3750 -9460 {
lab=rA6}
N 3600 -9480 3750 -9480 {
lab=rA7}
N 3600 -9500 3750 -9500 {
lab=rA8}
N 3600 -9540 3750 -9540 {
lab=rA10}
N 3600 -9520 3750 -9520 {
lab=rA9}
N 3600 -9560 3750 -9560 {
lab=rA11}
N 3600 -9580 3750 -9580 {
lab=rA12}
N 3600 -9600 3750 -9600 {
lab=rA13}
N 3600 -9620 3750 -9620 {
lab=rA14}
N 3600 -9640 3750 -9640 {
lab=rA15}
N 3600 -9360 3750 -9360 {
lab=rA1}
N 3750 -9360 3810 -9360 {
lab=rA1}
N 3750 -9380 3810 -9380 {
lab=rA2}
N 3750 -9400 3810 -9400 {
lab=rA3}
N 3750 -9420 3810 -9420 {
lab=rA4}
N 3750 -9440 3810 -9440 {
lab=rA5}
N 3750 -9460 3810 -9460 {
lab=rA6}
N 3750 -9480 3810 -9480 {
lab=rA7}
N 3750 -9500 3810 -9500 {
lab=rA8}
N 3750 -9520 3810 -9520 {
lab=rA9}
N 3750 -9540 3810 -9540 {
lab=rA10}
N 3750 -9560 3810 -9560 {
lab=rA11}
N 3750 -9580 3810 -9580 {
lab=rA12}
N 3750 -9600 3810 -9600 {
lab=rA13}
N 3750 -9620 3810 -9620 {
lab=rA14}
N 3750 -9640 3810 -9640 {
lab=rA15}
N 3590 -9630 3590 -9290 {
lab=rA[0..15]
bus=true}
N 4110 -9340 4160 -9340 {
lab=rB0}
N 4110 -9360 4160 -9360 {
lab=rB1}
N 4230 -9350 4230 -9290 {
lab=rB[0..15]
bus=true}
N 4110 -9380 4160 -9380 {
lab=rB2}
N 4110 -9400 4160 -9400 {
lab=rB3}
N 4110 -9420 4160 -9420 {
lab=rB4}
N 4110 -9440 4160 -9440 {
lab=rB5}
N 4110 -9460 4160 -9460 {
lab=rB6}
N 4110 -9480 4160 -9480 {
lab=rB7}
N 4110 -9500 4160 -9500 {
lab=rB8}
N 4110 -9520 4160 -9520 {
lab=rB9}
N 4110 -9540 4160 -9540 {
lab=rB10}
N 4110 -9560 4160 -9560 {
lab=rB11}
N 4110 -9580 4160 -9580 {
lab=rB12}
N 4110 -9600 4160 -9600 {
lab=rB13}
N 4110 -9620 4160 -9620 {
lab=rB14}
N 4110 -9640 4160 -9640 {
lab=rB15}
N 4230 -9630 4230 -9350 {
lab=rB[0..15]
bus=true}
N 3750 -8660 3810 -8660 {
lab=cA0}
N 3750 -8680 3810 -8680 {
lab=cA1}
N 3750 -8700 3810 -8700 {
lab=cA2}
N 3750 -8720 3810 -8720 {
lab=cA3}
N 3750 -8740 3810 -8740 {
lab=cA4}
N 3750 -8760 3810 -8760 {
lab=cA5}
N 3750 -8780 3810 -8780 {
lab=cA6}
N 3750 -8800 3810 -8800 {
lab=cA7}
N 3750 -8820 3810 -8820 {
lab=cA8}
N 3750 -8840 3810 -8840 {
lab=cA9}
N 3750 -8860 3810 -8860 {
lab=cA10}
N 3750 -8880 3810 -8880 {
lab=cA11}
N 3750 -8900 3810 -8900 {
lab=cA12}
N 3750 -8920 3810 -8920 {
lab=cA13}
N 3750 -8940 3810 -8940 {
lab=cA14}
N 3750 -8960 3810 -8960 {
lab=cA15}
N 3740 -8950 3740 -8650 {bus=true
lab=cA[0..15]}
N 3740 -8650 3740 -8620 {bus=true
lab=cA[0..15]}
N 4110 -8660 4170 -8660 {
lab=cB0}
N 4110 -8680 4170 -8680 {
lab=cB1}
N 4110 -8700 4170 -8700 {
lab=cB2}
N 4110 -8720 4170 -8720 {
lab=cB3}
N 4110 -8740 4170 -8740 {
lab=cB4}
N 4110 -8760 4170 -8760 {
lab=cB5}
N 4110 -8780 4170 -8780 {
lab=cB6}
N 4110 -8800 4170 -8800 {
lab=cB7}
N 4110 -8820 4170 -8820 {
lab=cB8}
N 4110 -8840 4170 -8840 {
lab=cB9}
N 4110 -8860 4170 -8860 {
lab=cB10}
N 4110 -8880 4170 -8880 {
lab=cB11}
N 4110 -8900 4170 -8900 {
lab=cB12}
N 4110 -8920 4170 -8920 {
lab=cB13}
N 4110 -8940 4170 -8940 {
lab=cB14}
N 4110 -8960 4170 -8960 {
lab=cB15}
N 4180 -8950 4180 -8650 {bus=true
lab=cB[0..15]}
N 4180 -8650 4180 -8620 {bus=true
lab=cB[0..15]}
N 2340 -9930 2400 -9930 {
lab=col3_sel}
N 2340 -9950 2400 -9950 {
lab=row4_sel}
N 2340 -9710 2400 -9710 {
lab=Vcplus}
N 2340 -9730 2400 -9730 {
lab=Vcminus}
N 2340 -9750 2400 -9750 {
lab=Vref}
N 2340 -9770 2400 -9770 {
lab=Vref_comp}
N 2340 -9790 2400 -9790 {
lab=RISC_CLK}
N 2340 -9850 2400 -9850 {
lab=SAMPLE}
N 2340 -9830 2400 -9830 {
lab=Vrminus}
N 2340 -9810 2400 -9810 {
lab=Vrplus}
N 2340 -9890 2400 -9890 {
lab=WR}
N 2340 -9910 2400 -9910 {
lab=Vgnr}
N 2340 -9870 2400 -9870 {
lab=Vgpr}
N 3040 -9920 3100 -9920 {
lab=col4_sel}
N 3040 -9940 3100 -9940 {
lab=row4_sel}
N 3040 -9700 3100 -9700 {
lab=Vcplus}
N 3040 -9720 3100 -9720 {
lab=Vcminus}
N 3040 -9740 3100 -9740 {
lab=Vref}
N 3040 -9760 3100 -9760 {
lab=Vref_comp}
N 3040 -9780 3100 -9780 {
lab=RISC_CLK}
N 3040 -9840 3100 -9840 {
lab=SAMPLE}
N 3040 -9820 3100 -9820 {
lab=Vrminus}
N 3040 -9800 3100 -9800 {
lab=Vrplus}
N 3040 -9880 3100 -9880 {
lab=WR}
N 3040 -9900 3100 -9900 {
lab=Vgnr}
N 3040 -9860 3100 -9860 {
lab=Vgpr}
N 3750 -9920 3810 -9920 {
lab=col5_sel}
N 3750 -9940 3810 -9940 {
lab=row4_sel}
N 3750 -9700 3810 -9700 {
lab=Vcplus}
N 3750 -9720 3810 -9720 {
lab=Vcminus}
N 3750 -9740 3810 -9740 {
lab=Vref}
N 3750 -9760 3810 -9760 {
lab=Vref_comp}
N 3750 -9780 3810 -9780 {
lab=RISC_CLK}
N 3750 -9840 3810 -9840 {
lab=SAMPLE}
N 3750 -9820 3810 -9820 {
lab=Vrminus}
N 3750 -9800 3810 -9800 {
lab=Vrplus}
N 3750 -9880 3810 -9880 {
lab=WR}
N 3750 -9900 3810 -9900 {
lab=Vgnr}
N 3750 -9860 3810 -9860 {
lab=Vgpr}
N 190 -11420 250 -11420 {
lab=rA0}
N 600 -11420 660 -11420 {
lab=rB0}
N 600 -11440 660 -11440 {
lab=rB1}
N 600 -11460 660 -11460 {
lab=rB2}
N 600 -11480 660 -11480 {
lab=rB3}
N 600 -11500 660 -11500 {
lab=rB4}
N 600 -11520 660 -11520 {
lab=rB5}
N 600 -11540 660 -11540 {
lab=rB6}
N 600 -11560 660 -11560 {
lab=rB7}
N 600 -11580 660 -11580 {
lab=rB8}
N 600 -11600 660 -11600 {
lab=rB9}
N 600 -11620 660 -11620 {
lab=rB10}
N 600 -11640 660 -11640 {
lab=rB11}
N 600 -11660 660 -11660 {
lab=rB12}
N 600 -11680 660 -11680 {
lab=rB13}
N 600 -11700 660 -11700 {
lab=rB14}
N 600 -11720 660 -11720 {
lab=rB15}
N 190 -11080 250 -11080 {
lab=WL0}
N 190 -11100 250 -11100 {
lab=WL1}
N 190 -11120 250 -11120 {
lab=WL2}
N 190 -11140 250 -11140 {
lab=WL3}
N 190 -11160 250 -11160 {
lab=WL4}
N 190 -11180 250 -11180 {
lab=WL5}
N 190 -11200 250 -11200 {
lab=WL6}
N 190 -11220 250 -11220 {
lab=WL7}
N 190 -11240 250 -11240 {
lab=WL8}
N 190 -11260 250 -11260 {
lab=WL9}
N 190 -11280 250 -11280 {
lab=WL10}
N 190 -11300 250 -11300 {
lab=WL11}
N 190 -11320 250 -11320 {
lab=WL12}
N 190 -11340 250 -11340 {
lab=WL13}
N 190 -11360 250 -11360 {
lab=WL14}
N 190 -11380 250 -11380 {
lab=WL15}
N 190 -10740 250 -10740 {
lab=cA0}
N 190 -10760 250 -10760 {
lab=cA1}
N 190 -10780 250 -10780 {
lab=cA2}
N 190 -10800 250 -10800 {
lab=cA3}
N 190 -10820 250 -10820 {
lab=cA4}
N 190 -10840 250 -10840 {
lab=cA5}
N 190 -10860 250 -10860 {
lab=cA6}
N 190 -10880 250 -10880 {
lab=cA7}
N 190 -10900 250 -10900 {
lab=cA8}
N 190 -10920 250 -10920 {
lab=cA9}
N 190 -10940 250 -10940 {
lab=cA10}
N 190 -10960 250 -10960 {
lab=cA11}
N 190 -10980 250 -10980 {
lab=cA12}
N 190 -11000 250 -11000 {
lab=cA13}
N 190 -11020 250 -11020 {
lab=cA14}
N 190 -11040 250 -11040 {
lab=cA15}
N 190 -12000 250 -12000 {
lab=col0_sel}
N 190 -12020 250 -12020 {
lab=row5_sel}
N 190 -11960 250 -11960 {
lab=WR}
N 190 -11980 250 -11980 {
lab=Vgnr}
N 190 -11940 250 -11940 {
lab=Vgpr}
N 190 -11780 250 -11780 {
lab=Vcplus}
N 190 -11800 250 -11800 {
lab=Vcminus}
N 190 -11820 250 -11820 {
lab=Vref}
N 190 -11840 250 -11840 {
lab=Vref_comp}
N 190 -11860 250 -11860 {
lab=RISC_CLK}
N 550 -11960 610 -11960 {
lab=vssd1}
N 550 -11980 610 -11980 {
lab=vdda1}
N 550 -12000 610 -12000 {
lab=vccd1}
N 550 -12020 610 -12020 {
lab=latch_high0}
N 1970 -12010 2030 -12010 {
lab=latch_high2}
N 2700 -11960 2760 -11960 {
lab=vssd1}
N 2700 -11980 2760 -11980 {
lab=vdda1}
N 2700 -12000 2760 -12000 {
lab=vccd1}
N 2700 -12020 2760 -12020 {
lab=latch_high3}
N 3400 -11950 3460 -11950 {
lab=vssd1}
N 3400 -11970 3460 -11970 {
lab=vdda1}
N 3400 -11990 3460 -11990 {
lab=vccd1}
N 3400 -12010 3460 -12010 {
lab=latch_high4}
N 4110 -11950 4170 -11950 {
lab=vssd1}
N 4110 -11970 4170 -11970 {
lab=vdda1}
N 4110 -11990 4170 -11990 {
lab=vccd1}
N 4110 -12010 4170 -12010 {
lab=latch_high5}
N 130 -11080 190 -11080 {
lab=WL0}
N 130 -11100 190 -11100 {
lab=WL1}
N 130 -11120 190 -11120 {
lab=WL2}
N 130 -11140 190 -11140 {
lab=WL3}
N 130 -11160 190 -11160 {
lab=WL4}
N 130 -11180 190 -11180 {
lab=WL5}
N 130 -11200 190 -11200 {
lab=WL6}
N 130 -11220 190 -11220 {
lab=WL7}
N 130 -11240 190 -11240 {
lab=WL8}
N 130 -11260 190 -11260 {
lab=WL9}
N 130 -11280 190 -11280 {
lab=WL10}
N 130 -11300 190 -11300 {
lab=WL11}
N 130 -11320 190 -11320 {
lab=WL12}
N 130 -11340 190 -11340 {
lab=WL13}
N 130 -11360 190 -11360 {
lab=WL14}
N 130 -11380 190 -11380 {
lab=WL15}
N 70 -11080 130 -11080 {
lab=WL0}
N 70 -11100 130 -11100 {
lab=WL1}
N 70 -11120 130 -11120 {
lab=WL2}
N 70 -11140 130 -11140 {
lab=WL3}
N 70 -11160 130 -11160 {
lab=WL4}
N 70 -11180 130 -11180 {
lab=WL5}
N 70 -11200 130 -11200 {
lab=WL6}
N 70 -11220 130 -11220 {
lab=WL7}
N 70 -11240 130 -11240 {
lab=WL8}
N 70 -11260 130 -11260 {
lab=WL9}
N 70 -11280 130 -11280 {
lab=WL10}
N 70 -11300 130 -11300 {
lab=WL11}
N 70 -11320 130 -11320 {
lab=WL12}
N 70 -11340 130 -11340 {
lab=WL13}
N 70 -11360 130 -11360 {
lab=WL14}
N 70 -11380 130 -11380 {
lab=WL15}
N 60 -11370 60 -11070 {bus=true
lab=WL[0..15]}
N 60 -11070 60 -11040 {bus=true
lab=WL[0..15]}
N 910 -11080 970 -11080 {
lab=WL0}
N 910 -11100 970 -11100 {
lab=WL1}
N 910 -11120 970 -11120 {
lab=WL2}
N 910 -11140 970 -11140 {
lab=WL3}
N 910 -11160 970 -11160 {
lab=WL4}
N 910 -11180 970 -11180 {
lab=WL5}
N 910 -11200 970 -11200 {
lab=WL6}
N 910 -11220 970 -11220 {
lab=WL7}
N 910 -11240 970 -11240 {
lab=WL8}
N 910 -11260 970 -11260 {
lab=WL9}
N 910 -11280 970 -11280 {
lab=WL10}
N 910 -11300 970 -11300 {
lab=WL11}
N 910 -11320 970 -11320 {
lab=WL12}
N 910 -11340 970 -11340 {
lab=WL13}
N 910 -11360 970 -11360 {
lab=WL14}
N 910 -11380 970 -11380 {
lab=WL15}
N 850 -11080 910 -11080 {
lab=WL0}
N 850 -11100 910 -11100 {
lab=WL1}
N 850 -11120 910 -11120 {
lab=WL2}
N 850 -11140 910 -11140 {
lab=WL3}
N 850 -11160 910 -11160 {
lab=WL4}
N 850 -11180 910 -11180 {
lab=WL5}
N 850 -11200 910 -11200 {
lab=WL6}
N 850 -11220 910 -11220 {
lab=WL7}
N 850 -11240 910 -11240 {
lab=WL8}
N 850 -11260 910 -11260 {
lab=WL9}
N 850 -11280 910 -11280 {
lab=WL10}
N 850 -11300 910 -11300 {
lab=WL11}
N 850 -11320 910 -11320 {
lab=WL12}
N 850 -11340 910 -11340 {
lab=WL13}
N 850 -11360 910 -11360 {
lab=WL14}
N 850 -11380 910 -11380 {
lab=WL15}
N 790 -11080 850 -11080 {
lab=WL0}
N 790 -11100 850 -11100 {
lab=WL1}
N 790 -11120 850 -11120 {
lab=WL2}
N 790 -11140 850 -11140 {
lab=WL3}
N 790 -11160 850 -11160 {
lab=WL4}
N 790 -11180 850 -11180 {
lab=WL5}
N 790 -11200 850 -11200 {
lab=WL6}
N 790 -11220 850 -11220 {
lab=WL7}
N 790 -11240 850 -11240 {
lab=WL8}
N 790 -11260 850 -11260 {
lab=WL9}
N 790 -11280 850 -11280 {
lab=WL10}
N 790 -11300 850 -11300 {
lab=WL11}
N 790 -11320 850 -11320 {
lab=WL12}
N 790 -11340 850 -11340 {
lab=WL13}
N 790 -11360 850 -11360 {
lab=WL14}
N 790 -11380 850 -11380 {
lab=WL15}
N 780 -11370 780 -11070 {bus=true
lab=WL[0..15]}
N 780 -11070 780 -11040 {bus=true
lab=WL[0..15]}
N 1610 -11070 1670 -11070 {
lab=WL0}
N 1610 -11090 1670 -11090 {
lab=WL1}
N 1610 -11110 1670 -11110 {
lab=WL2}
N 1610 -11130 1670 -11130 {
lab=WL3}
N 1610 -11150 1670 -11150 {
lab=WL4}
N 1610 -11170 1670 -11170 {
lab=WL5}
N 1610 -11190 1670 -11190 {
lab=WL6}
N 1610 -11210 1670 -11210 {
lab=WL7}
N 1610 -11230 1670 -11230 {
lab=WL8}
N 1610 -11250 1670 -11250 {
lab=WL9}
N 1610 -11270 1670 -11270 {
lab=WL10}
N 1610 -11290 1670 -11290 {
lab=WL11}
N 1610 -11310 1670 -11310 {
lab=WL12}
N 1610 -11330 1670 -11330 {
lab=WL13}
N 1610 -11350 1670 -11350 {
lab=WL14}
N 1610 -11370 1670 -11370 {
lab=WL15}
N 1550 -11070 1610 -11070 {
lab=WL0}
N 1550 -11090 1610 -11090 {
lab=WL1}
N 1550 -11110 1610 -11110 {
lab=WL2}
N 1550 -11130 1610 -11130 {
lab=WL3}
N 1550 -11150 1610 -11150 {
lab=WL4}
N 1550 -11170 1610 -11170 {
lab=WL5}
N 1550 -11190 1610 -11190 {
lab=WL6}
N 1550 -11210 1610 -11210 {
lab=WL7}
N 1550 -11230 1610 -11230 {
lab=WL8}
N 1550 -11250 1610 -11250 {
lab=WL9}
N 1550 -11270 1610 -11270 {
lab=WL10}
N 1550 -11290 1610 -11290 {
lab=WL11}
N 1550 -11310 1610 -11310 {
lab=WL12}
N 1550 -11330 1610 -11330 {
lab=WL13}
N 1550 -11350 1610 -11350 {
lab=WL14}
N 1550 -11370 1610 -11370 {
lab=WL15}
N 1490 -11070 1550 -11070 {
lab=WL0}
N 1490 -11090 1550 -11090 {
lab=WL1}
N 1490 -11110 1550 -11110 {
lab=WL2}
N 1490 -11130 1550 -11130 {
lab=WL3}
N 1490 -11150 1550 -11150 {
lab=WL4}
N 1490 -11170 1550 -11170 {
lab=WL5}
N 1490 -11190 1550 -11190 {
lab=WL6}
N 1490 -11210 1550 -11210 {
lab=WL7}
N 1490 -11230 1550 -11230 {
lab=WL8}
N 1490 -11250 1550 -11250 {
lab=WL9}
N 1490 -11270 1550 -11270 {
lab=WL10}
N 1490 -11290 1550 -11290 {
lab=WL11}
N 1490 -11310 1550 -11310 {
lab=WL12}
N 1490 -11330 1550 -11330 {
lab=WL13}
N 1490 -11350 1550 -11350 {
lab=WL14}
N 1490 -11370 1550 -11370 {
lab=WL15}
N 1480 -11360 1480 -11060 {bus=true
lab=WL[0..15]}
N 1480 -11060 1480 -11030 {bus=true
lab=WL[0..15]}
N 2340 -11080 2400 -11080 {
lab=WL0}
N 2340 -11100 2400 -11100 {
lab=WL1}
N 2340 -11120 2400 -11120 {
lab=WL2}
N 2340 -11140 2400 -11140 {
lab=WL3}
N 2340 -11160 2400 -11160 {
lab=WL4}
N 2340 -11180 2400 -11180 {
lab=WL5}
N 2340 -11200 2400 -11200 {
lab=WL6}
N 2340 -11220 2400 -11220 {
lab=WL7}
N 2340 -11240 2400 -11240 {
lab=WL8}
N 2340 -11260 2400 -11260 {
lab=WL9}
N 2340 -11280 2400 -11280 {
lab=WL10}
N 2340 -11300 2400 -11300 {
lab=WL11}
N 2340 -11320 2400 -11320 {
lab=WL12}
N 2340 -11340 2400 -11340 {
lab=WL13}
N 2340 -11360 2400 -11360 {
lab=WL14}
N 2340 -11380 2400 -11380 {
lab=WL15}
N 2280 -11080 2340 -11080 {
lab=WL0}
N 2280 -11100 2340 -11100 {
lab=WL1}
N 2280 -11120 2340 -11120 {
lab=WL2}
N 2280 -11140 2340 -11140 {
lab=WL3}
N 2280 -11160 2340 -11160 {
lab=WL4}
N 2280 -11180 2340 -11180 {
lab=WL5}
N 2280 -11200 2340 -11200 {
lab=WL6}
N 2280 -11220 2340 -11220 {
lab=WL7}
N 2280 -11240 2340 -11240 {
lab=WL8}
N 2280 -11260 2340 -11260 {
lab=WL9}
N 2280 -11280 2340 -11280 {
lab=WL10}
N 2280 -11300 2340 -11300 {
lab=WL11}
N 2280 -11320 2340 -11320 {
lab=WL12}
N 2280 -11340 2340 -11340 {
lab=WL13}
N 2280 -11360 2340 -11360 {
lab=WL14}
N 2280 -11380 2340 -11380 {
lab=WL15}
N 2220 -11080 2280 -11080 {
lab=WL0}
N 2220 -11100 2280 -11100 {
lab=WL1}
N 2220 -11120 2280 -11120 {
lab=WL2}
N 2220 -11140 2280 -11140 {
lab=WL3}
N 2220 -11160 2280 -11160 {
lab=WL4}
N 2220 -11180 2280 -11180 {
lab=WL5}
N 2220 -11200 2280 -11200 {
lab=WL6}
N 2220 -11220 2280 -11220 {
lab=WL7}
N 2220 -11240 2280 -11240 {
lab=WL8}
N 2220 -11260 2280 -11260 {
lab=WL9}
N 2220 -11280 2280 -11280 {
lab=WL10}
N 2220 -11300 2280 -11300 {
lab=WL11}
N 2220 -11320 2280 -11320 {
lab=WL12}
N 2220 -11340 2280 -11340 {
lab=WL13}
N 2220 -11360 2280 -11360 {
lab=WL14}
N 2220 -11380 2280 -11380 {
lab=WL15}
N 2210 -11370 2210 -11070 {bus=true
lab=WL[0..15]}
N 2210 -11070 2210 -11040 {bus=true
lab=WL[0..15]}
N 3040 -11070 3100 -11070 {
lab=WL0}
N 3040 -11090 3100 -11090 {
lab=WL1}
N 3040 -11110 3100 -11110 {
lab=WL2}
N 3040 -11130 3100 -11130 {
lab=WL3}
N 3040 -11150 3100 -11150 {
lab=WL4}
N 3040 -11170 3100 -11170 {
lab=WL5}
N 3040 -11190 3100 -11190 {
lab=WL6}
N 3040 -11210 3100 -11210 {
lab=WL7}
N 3040 -11230 3100 -11230 {
lab=WL8}
N 3040 -11250 3100 -11250 {
lab=WL9}
N 3040 -11270 3100 -11270 {
lab=WL10}
N 3040 -11290 3100 -11290 {
lab=WL11}
N 3040 -11310 3100 -11310 {
lab=WL12}
N 3040 -11330 3100 -11330 {
lab=WL13}
N 3040 -11350 3100 -11350 {
lab=WL14}
N 3040 -11370 3100 -11370 {
lab=WL15}
N 2980 -11070 3040 -11070 {
lab=WL0}
N 2980 -11090 3040 -11090 {
lab=WL1}
N 2980 -11110 3040 -11110 {
lab=WL2}
N 2980 -11130 3040 -11130 {
lab=WL3}
N 2980 -11150 3040 -11150 {
lab=WL4}
N 2980 -11170 3040 -11170 {
lab=WL5}
N 2980 -11190 3040 -11190 {
lab=WL6}
N 2980 -11210 3040 -11210 {
lab=WL7}
N 2980 -11230 3040 -11230 {
lab=WL8}
N 2980 -11250 3040 -11250 {
lab=WL9}
N 2980 -11270 3040 -11270 {
lab=WL10}
N 2980 -11290 3040 -11290 {
lab=WL11}
N 2980 -11310 3040 -11310 {
lab=WL12}
N 2980 -11330 3040 -11330 {
lab=WL13}
N 2980 -11350 3040 -11350 {
lab=WL14}
N 2980 -11370 3040 -11370 {
lab=WL15}
N 2920 -11070 2980 -11070 {
lab=WL0}
N 2920 -11090 2980 -11090 {
lab=WL1}
N 2920 -11110 2980 -11110 {
lab=WL2}
N 2920 -11130 2980 -11130 {
lab=WL3}
N 2920 -11150 2980 -11150 {
lab=WL4}
N 2920 -11170 2980 -11170 {
lab=WL5}
N 2920 -11190 2980 -11190 {
lab=WL6}
N 2920 -11210 2980 -11210 {
lab=WL7}
N 2920 -11230 2980 -11230 {
lab=WL8}
N 2920 -11250 2980 -11250 {
lab=WL9}
N 2920 -11270 2980 -11270 {
lab=WL10}
N 2920 -11290 2980 -11290 {
lab=WL11}
N 2920 -11310 2980 -11310 {
lab=WL12}
N 2920 -11330 2980 -11330 {
lab=WL13}
N 2920 -11350 2980 -11350 {
lab=WL14}
N 2920 -11370 2980 -11370 {
lab=WL15}
N 2910 -11360 2910 -11060 {bus=true
lab=WL[0..15]}
N 2910 -11060 2910 -11030 {bus=true
lab=WL[0..15]}
N 3750 -11070 3810 -11070 {
lab=WL0}
N 3750 -11090 3810 -11090 {
lab=WL1}
N 3750 -11110 3810 -11110 {
lab=WL2}
N 3750 -11130 3810 -11130 {
lab=WL3}
N 3750 -11150 3810 -11150 {
lab=WL4}
N 3750 -11170 3810 -11170 {
lab=WL5}
N 3750 -11190 3810 -11190 {
lab=WL6}
N 3750 -11210 3810 -11210 {
lab=WL7}
N 3750 -11230 3810 -11230 {
lab=WL8}
N 3750 -11250 3810 -11250 {
lab=WL9}
N 3750 -11270 3810 -11270 {
lab=WL10}
N 3750 -11290 3810 -11290 {
lab=WL11}
N 3750 -11310 3810 -11310 {
lab=WL12}
N 3750 -11330 3810 -11330 {
lab=WL13}
N 3750 -11350 3810 -11350 {
lab=WL14}
N 3750 -11370 3810 -11370 {
lab=WL15}
N 3690 -11070 3750 -11070 {
lab=WL0}
N 3690 -11090 3750 -11090 {
lab=WL1}
N 3690 -11110 3750 -11110 {
lab=WL2}
N 3690 -11130 3750 -11130 {
lab=WL3}
N 3690 -11150 3750 -11150 {
lab=WL4}
N 3690 -11170 3750 -11170 {
lab=WL5}
N 3690 -11190 3750 -11190 {
lab=WL6}
N 3690 -11210 3750 -11210 {
lab=WL7}
N 3690 -11230 3750 -11230 {
lab=WL8}
N 3690 -11250 3750 -11250 {
lab=WL9}
N 3690 -11270 3750 -11270 {
lab=WL10}
N 3690 -11290 3750 -11290 {
lab=WL11}
N 3690 -11310 3750 -11310 {
lab=WL12}
N 3690 -11330 3750 -11330 {
lab=WL13}
N 3690 -11350 3750 -11350 {
lab=WL14}
N 3690 -11370 3750 -11370 {
lab=WL15}
N 3630 -11070 3690 -11070 {
lab=WL0}
N 3630 -11090 3690 -11090 {
lab=WL1}
N 3630 -11110 3690 -11110 {
lab=WL2}
N 3630 -11130 3690 -11130 {
lab=WL3}
N 3630 -11150 3690 -11150 {
lab=WL4}
N 3630 -11170 3690 -11170 {
lab=WL5}
N 3630 -11190 3690 -11190 {
lab=WL6}
N 3630 -11210 3690 -11210 {
lab=WL7}
N 3630 -11230 3690 -11230 {
lab=WL8}
N 3630 -11250 3690 -11250 {
lab=WL9}
N 3630 -11270 3690 -11270 {
lab=WL10}
N 3630 -11290 3690 -11290 {
lab=WL11}
N 3630 -11310 3690 -11310 {
lab=WL12}
N 3630 -11330 3690 -11330 {
lab=WL13}
N 3630 -11350 3690 -11350 {
lab=WL14}
N 3630 -11370 3690 -11370 {
lab=WL15}
N 3620 -11360 3620 -11060 {bus=true
lab=WL[0..15]}
N 3620 -11060 3620 -11030 {bus=true
lab=WL[0..15]}
N 40 -11420 190 -11420 {
lab=rA0}
N 40 -11460 190 -11460 {
lab=rA2}
N 40 -11480 190 -11480 {
lab=rA3}
N 40 -11500 190 -11500 {
lab=rA4}
N 40 -11520 190 -11520 {
lab=rA5}
N 40 -11540 190 -11540 {
lab=rA6}
N 40 -11560 190 -11560 {
lab=rA7}
N 40 -11580 190 -11580 {
lab=rA8}
N 40 -11620 190 -11620 {
lab=rA10}
N 40 -11600 190 -11600 {
lab=rA9}
N 40 -11640 190 -11640 {
lab=rA11}
N 40 -11660 190 -11660 {
lab=rA12}
N 40 -11680 190 -11680 {
lab=rA13}
N 40 -11700 190 -11700 {
lab=rA14}
N 40 -11720 190 -11720 {
lab=rA15}
N 190 -11920 250 -11920 {
lab=SAMPLE}
N 190 -11900 250 -11900 {
lab=Vrminus}
N 190 -11880 250 -11880 {
lab=Vrplus}
N 40 -11440 190 -11440 {
lab=rA1}
N 190 -11440 250 -11440 {
lab=rA1}
N 190 -11460 250 -11460 {
lab=rA2}
N 190 -11480 250 -11480 {
lab=rA3}
N 190 -11500 250 -11500 {
lab=rA4}
N 190 -11520 250 -11520 {
lab=rA5}
N 190 -11540 250 -11540 {
lab=rA6}
N 190 -11560 250 -11560 {
lab=rA7}
N 190 -11580 250 -11580 {
lab=rA8}
N 190 -11600 250 -11600 {
lab=rA9}
N 190 -11620 250 -11620 {
lab=rA10}
N 190 -11640 250 -11640 {
lab=rA11}
N 190 -11660 250 -11660 {
lab=rA12}
N 190 -11680 250 -11680 {
lab=rA13}
N 190 -11700 250 -11700 {
lab=rA14}
N 190 -11720 250 -11720 {
lab=rA15}
N 30 -11710 30 -11370 {
lab=rA[0..15]
bus=true}
N 550 -11420 600 -11420 {
lab=rB0}
N 550 -11440 600 -11440 {
lab=rB1}
N 670 -11430 670 -11370 {
lab=rB[0..15]
bus=true}
N 550 -11460 600 -11460 {
lab=rB2}
N 550 -11480 600 -11480 {
lab=rB3}
N 550 -11500 600 -11500 {
lab=rB4}
N 550 -11520 600 -11520 {
lab=rB5}
N 550 -11540 600 -11540 {
lab=rB6}
N 550 -11560 600 -11560 {
lab=rB7}
N 550 -11580 600 -11580 {
lab=rB8}
N 550 -11600 600 -11600 {
lab=rB9}
N 550 -11620 600 -11620 {
lab=rB10}
N 550 -11640 600 -11640 {
lab=rB11}
N 550 -11660 600 -11660 {
lab=rB12}
N 550 -11680 600 -11680 {
lab=rB13}
N 550 -11700 600 -11700 {
lab=rB14}
N 550 -11720 600 -11720 {
lab=rB15}
N 670 -11710 670 -11430 {
lab=rB[0..15]
bus=true}
N 180 -11030 180 -10730 {bus=true
lab=cA[0..15]}
N 180 -10730 180 -10700 {bus=true
lab=cA[0..15]}
N 550 -10740 610 -10740 {
lab=cB0}
N 550 -10760 610 -10760 {
lab=cB1}
N 550 -10780 610 -10780 {
lab=cB2}
N 550 -10800 610 -10800 {
lab=cB3}
N 550 -10820 610 -10820 {
lab=cB4}
N 550 -10840 610 -10840 {
lab=cB5}
N 550 -10860 610 -10860 {
lab=cB6}
N 550 -10880 610 -10880 {
lab=cB7}
N 550 -10900 610 -10900 {
lab=cB8}
N 550 -10920 610 -10920 {
lab=cB9}
N 550 -10940 610 -10940 {
lab=cB10}
N 550 -10960 610 -10960 {
lab=cB11}
N 550 -10980 610 -10980 {
lab=cB12}
N 550 -11000 610 -11000 {
lab=cB13}
N 550 -11020 610 -11020 {
lab=cB14}
N 550 -11040 610 -11040 {
lab=cB15}
N 620 -11030 620 -10730 {bus=true
lab=cB[0..15]}
N 620 -10730 620 -10700 {bus=true
lab=cB[0..15]}
N 910 -11420 970 -11420 {
lab=rA0}
N 1320 -11420 1380 -11420 {
lab=rB0}
N 1320 -11440 1380 -11440 {
lab=rB1}
N 1320 -11460 1380 -11460 {
lab=rB2}
N 1320 -11480 1380 -11480 {
lab=rB3}
N 1320 -11500 1380 -11500 {
lab=rB4}
N 1320 -11520 1380 -11520 {
lab=rB5}
N 1320 -11540 1380 -11540 {
lab=rB6}
N 1320 -11560 1380 -11560 {
lab=rB7}
N 1320 -11580 1380 -11580 {
lab=rB8}
N 1320 -11600 1380 -11600 {
lab=rB9}
N 1320 -11620 1380 -11620 {
lab=rB10}
N 1320 -11640 1380 -11640 {
lab=rB11}
N 1320 -11660 1380 -11660 {
lab=rB12}
N 1320 -11680 1380 -11680 {
lab=rB13}
N 1320 -11700 1380 -11700 {
lab=rB14}
N 1320 -11720 1380 -11720 {
lab=rB15}
N 910 -12000 970 -12000 {
lab=col1_sel}
N 910 -12020 970 -12020 {
lab=row5_sel}
N 910 -11780 970 -11780 {
lab=Vcplus}
N 910 -11800 970 -11800 {
lab=Vcminus}
N 910 -11820 970 -11820 {
lab=Vref}
N 910 -11840 970 -11840 {
lab=Vref_comp}
N 910 -11860 970 -11860 {
lab=RISC_CLK}
N 1270 -11960 1330 -11960 {
lab=vssd1}
N 1270 -11980 1330 -11980 {
lab=vdda1}
N 1270 -12000 1330 -12000 {
lab=vccd1}
N 1270 -12020 1330 -12020 {
lab=latch_high1}
N 760 -11420 910 -11420 {
lab=rA0}
N 760 -11460 910 -11460 {
lab=rA2}
N 760 -11480 910 -11480 {
lab=rA3}
N 760 -11500 910 -11500 {
lab=rA4}
N 760 -11520 910 -11520 {
lab=rA5}
N 760 -11540 910 -11540 {
lab=rA6}
N 760 -11560 910 -11560 {
lab=rA7}
N 760 -11580 910 -11580 {
lab=rA8}
N 760 -11620 910 -11620 {
lab=rA10}
N 760 -11600 910 -11600 {
lab=rA9}
N 760 -11640 910 -11640 {
lab=rA11}
N 760 -11660 910 -11660 {
lab=rA12}
N 760 -11680 910 -11680 {
lab=rA13}
N 760 -11700 910 -11700 {
lab=rA14}
N 760 -11720 910 -11720 {
lab=rA15}
N 910 -11920 970 -11920 {
lab=SAMPLE}
N 910 -11900 970 -11900 {
lab=Vrminus}
N 910 -11880 970 -11880 {
lab=Vrplus}
N 760 -11440 910 -11440 {
lab=rA1}
N 910 -11440 970 -11440 {
lab=rA1}
N 910 -11460 970 -11460 {
lab=rA2}
N 910 -11480 970 -11480 {
lab=rA3}
N 910 -11500 970 -11500 {
lab=rA4}
N 910 -11520 970 -11520 {
lab=rA5}
N 910 -11540 970 -11540 {
lab=rA6}
N 910 -11560 970 -11560 {
lab=rA7}
N 910 -11580 970 -11580 {
lab=rA8}
N 910 -11600 970 -11600 {
lab=rA9}
N 910 -11620 970 -11620 {
lab=rA10}
N 910 -11640 970 -11640 {
lab=rA11}
N 910 -11660 970 -11660 {
lab=rA12}
N 910 -11680 970 -11680 {
lab=rA13}
N 910 -11700 970 -11700 {
lab=rA14}
N 910 -11720 970 -11720 {
lab=rA15}
N 750 -11710 750 -11370 {
lab=rA[0..15]
bus=true}
N 1270 -11420 1320 -11420 {
lab=rB0}
N 1270 -11440 1320 -11440 {
lab=rB1}
N 1390 -11430 1390 -11370 {
lab=rB[0..15]
bus=true}
N 1270 -11460 1320 -11460 {
lab=rB2}
N 1270 -11480 1320 -11480 {
lab=rB3}
N 1270 -11500 1320 -11500 {
lab=rB4}
N 1270 -11520 1320 -11520 {
lab=rB5}
N 1270 -11540 1320 -11540 {
lab=rB6}
N 1270 -11560 1320 -11560 {
lab=rB7}
N 1270 -11580 1320 -11580 {
lab=rB8}
N 1270 -11600 1320 -11600 {
lab=rB9}
N 1270 -11620 1320 -11620 {
lab=rB10}
N 1270 -11640 1320 -11640 {
lab=rB11}
N 1270 -11660 1320 -11660 {
lab=rB12}
N 1270 -11680 1320 -11680 {
lab=rB13}
N 1270 -11700 1320 -11700 {
lab=rB14}
N 1270 -11720 1320 -11720 {
lab=rB15}
N 1390 -11710 1390 -11430 {
lab=rB[0..15]
bus=true}
N 910 -11960 970 -11960 {
lab=WR}
N 910 -11980 970 -11980 {
lab=Vgnr}
N 910 -11940 970 -11940 {
lab=Vgpr}
N 1610 -11990 1670 -11990 {
lab=col2_sel}
N 1610 -12010 1670 -12010 {
lab=row5_sel}
N 1610 -11770 1670 -11770 {
lab=Vcplus}
N 1610 -11790 1670 -11790 {
lab=Vcminus}
N 1610 -11810 1670 -11810 {
lab=Vref}
N 1610 -11830 1670 -11830 {
lab=Vref_comp}
N 1610 -11850 1670 -11850 {
lab=RISC_CLK}
N 1610 -11910 1670 -11910 {
lab=SAMPLE}
N 1610 -11890 1670 -11890 {
lab=Vrminus}
N 1610 -11870 1670 -11870 {
lab=Vrplus}
N 1610 -11950 1670 -11950 {
lab=WR}
N 1610 -11970 1670 -11970 {
lab=Vgnr}
N 1610 -11930 1670 -11930 {
lab=Vgpr}
N 1970 -11950 2030 -11950 {
lab=vssd1}
N 1970 -11970 2030 -11970 {
lab=vdda1}
N 1970 -11990 2030 -11990 {
lab=vccd1}
N 1610 -11410 1670 -11410 {
lab=rA0}
N 2020 -11410 2080 -11410 {
lab=rB0}
N 2020 -11430 2080 -11430 {
lab=rB1}
N 2020 -11450 2080 -11450 {
lab=rB2}
N 2020 -11470 2080 -11470 {
lab=rB3}
N 2020 -11490 2080 -11490 {
lab=rB4}
N 2020 -11510 2080 -11510 {
lab=rB5}
N 2020 -11530 2080 -11530 {
lab=rB6}
N 2020 -11550 2080 -11550 {
lab=rB7}
N 2020 -11570 2080 -11570 {
lab=rB8}
N 2020 -11590 2080 -11590 {
lab=rB9}
N 2020 -11610 2080 -11610 {
lab=rB10}
N 2020 -11630 2080 -11630 {
lab=rB11}
N 2020 -11650 2080 -11650 {
lab=rB12}
N 2020 -11670 2080 -11670 {
lab=rB13}
N 2020 -11690 2080 -11690 {
lab=rB14}
N 2020 -11710 2080 -11710 {
lab=rB15}
N 1460 -11410 1610 -11410 {
lab=rA0}
N 1460 -11450 1610 -11450 {
lab=rA2}
N 1460 -11470 1610 -11470 {
lab=rA3}
N 1460 -11490 1610 -11490 {
lab=rA4}
N 1460 -11510 1610 -11510 {
lab=rA5}
N 1460 -11530 1610 -11530 {
lab=rA6}
N 1460 -11550 1610 -11550 {
lab=rA7}
N 1460 -11570 1610 -11570 {
lab=rA8}
N 1460 -11610 1610 -11610 {
lab=rA10}
N 1460 -11590 1610 -11590 {
lab=rA9}
N 1460 -11630 1610 -11630 {
lab=rA11}
N 1460 -11650 1610 -11650 {
lab=rA12}
N 1460 -11670 1610 -11670 {
lab=rA13}
N 1460 -11690 1610 -11690 {
lab=rA14}
N 1460 -11710 1610 -11710 {
lab=rA15}
N 1460 -11430 1610 -11430 {
lab=rA1}
N 1610 -11430 1670 -11430 {
lab=rA1}
N 1610 -11450 1670 -11450 {
lab=rA2}
N 1610 -11470 1670 -11470 {
lab=rA3}
N 1610 -11490 1670 -11490 {
lab=rA4}
N 1610 -11510 1670 -11510 {
lab=rA5}
N 1610 -11530 1670 -11530 {
lab=rA6}
N 1610 -11550 1670 -11550 {
lab=rA7}
N 1610 -11570 1670 -11570 {
lab=rA8}
N 1610 -11590 1670 -11590 {
lab=rA9}
N 1610 -11610 1670 -11610 {
lab=rA10}
N 1610 -11630 1670 -11630 {
lab=rA11}
N 1610 -11650 1670 -11650 {
lab=rA12}
N 1610 -11670 1670 -11670 {
lab=rA13}
N 1610 -11690 1670 -11690 {
lab=rA14}
N 1610 -11710 1670 -11710 {
lab=rA15}
N 1450 -11700 1450 -11360 {
lab=rA[0..15]
bus=true}
N 1970 -11410 2020 -11410 {
lab=rB0}
N 1970 -11430 2020 -11430 {
lab=rB1}
N 2090 -11420 2090 -11360 {
lab=rB[0..15]
bus=true}
N 1970 -11450 2020 -11450 {
lab=rB2}
N 1970 -11470 2020 -11470 {
lab=rB3}
N 1970 -11490 2020 -11490 {
lab=rB4}
N 1970 -11510 2020 -11510 {
lab=rB5}
N 1970 -11530 2020 -11530 {
lab=rB6}
N 1970 -11550 2020 -11550 {
lab=rB7}
N 1970 -11570 2020 -11570 {
lab=rB8}
N 1970 -11590 2020 -11590 {
lab=rB9}
N 1970 -11610 2020 -11610 {
lab=rB10}
N 1970 -11630 2020 -11630 {
lab=rB11}
N 1970 -11650 2020 -11650 {
lab=rB12}
N 1970 -11670 2020 -11670 {
lab=rB13}
N 1970 -11690 2020 -11690 {
lab=rB14}
N 1970 -11710 2020 -11710 {
lab=rB15}
N 2090 -11700 2090 -11420 {
lab=rB[0..15]
bus=true}
N 910 -10740 970 -10740 {
lab=cA0}
N 910 -10760 970 -10760 {
lab=cA1}
N 910 -10780 970 -10780 {
lab=cA2}
N 910 -10800 970 -10800 {
lab=cA3}
N 910 -10820 970 -10820 {
lab=cA4}
N 910 -10840 970 -10840 {
lab=cA5}
N 910 -10860 970 -10860 {
lab=cA6}
N 910 -10880 970 -10880 {
lab=cA7}
N 910 -10900 970 -10900 {
lab=cA8}
N 910 -10920 970 -10920 {
lab=cA9}
N 910 -10940 970 -10940 {
lab=cA10}
N 910 -10960 970 -10960 {
lab=cA11}
N 910 -10980 970 -10980 {
lab=cA12}
N 910 -11000 970 -11000 {
lab=cA13}
N 910 -11020 970 -11020 {
lab=cA14}
N 910 -11040 970 -11040 {
lab=cA15}
N 900 -11030 900 -10730 {bus=true
lab=cA[0..15]}
N 900 -10730 900 -10700 {bus=true
lab=cA[0..15]}
N 1270 -10740 1330 -10740 {
lab=cB0}
N 1270 -10760 1330 -10760 {
lab=cB1}
N 1270 -10780 1330 -10780 {
lab=cB2}
N 1270 -10800 1330 -10800 {
lab=cB3}
N 1270 -10820 1330 -10820 {
lab=cB4}
N 1270 -10840 1330 -10840 {
lab=cB5}
N 1270 -10860 1330 -10860 {
lab=cB6}
N 1270 -10880 1330 -10880 {
lab=cB7}
N 1270 -10900 1330 -10900 {
lab=cB8}
N 1270 -10920 1330 -10920 {
lab=cB9}
N 1270 -10940 1330 -10940 {
lab=cB10}
N 1270 -10960 1330 -10960 {
lab=cB11}
N 1270 -10980 1330 -10980 {
lab=cB12}
N 1270 -11000 1330 -11000 {
lab=cB13}
N 1270 -11020 1330 -11020 {
lab=cB14}
N 1270 -11040 1330 -11040 {
lab=cB15}
N 1340 -11030 1340 -10730 {bus=true
lab=cB[0..15]}
N 1340 -10730 1340 -10700 {bus=true
lab=cB[0..15]}
N 1610 -10730 1670 -10730 {
lab=cA0}
N 1610 -10750 1670 -10750 {
lab=cA1}
N 1610 -10770 1670 -10770 {
lab=cA2}
N 1610 -10790 1670 -10790 {
lab=cA3}
N 1610 -10810 1670 -10810 {
lab=cA4}
N 1610 -10830 1670 -10830 {
lab=cA5}
N 1610 -10850 1670 -10850 {
lab=cA6}
N 1610 -10870 1670 -10870 {
lab=cA7}
N 1610 -10890 1670 -10890 {
lab=cA8}
N 1610 -10910 1670 -10910 {
lab=cA9}
N 1610 -10930 1670 -10930 {
lab=cA10}
N 1610 -10950 1670 -10950 {
lab=cA11}
N 1610 -10970 1670 -10970 {
lab=cA12}
N 1610 -10990 1670 -10990 {
lab=cA13}
N 1610 -11010 1670 -11010 {
lab=cA14}
N 1610 -11030 1670 -11030 {
lab=cA15}
N 1600 -11020 1600 -10720 {bus=true
lab=cA[0..15]}
N 1600 -10720 1600 -10690 {bus=true
lab=cA[0..15]}
N 1970 -10730 2030 -10730 {
lab=cB0}
N 1970 -10750 2030 -10750 {
lab=cB1}
N 1970 -10770 2030 -10770 {
lab=cB2}
N 1970 -10790 2030 -10790 {
lab=cB3}
N 1970 -10810 2030 -10810 {
lab=cB4}
N 1970 -10830 2030 -10830 {
lab=cB5}
N 1970 -10850 2030 -10850 {
lab=cB6}
N 1970 -10870 2030 -10870 {
lab=cB7}
N 1970 -10890 2030 -10890 {
lab=cB8}
N 1970 -10910 2030 -10910 {
lab=cB9}
N 1970 -10930 2030 -10930 {
lab=cB10}
N 1970 -10950 2030 -10950 {
lab=cB11}
N 1970 -10970 2030 -10970 {
lab=cB12}
N 1970 -10990 2030 -10990 {
lab=cB13}
N 1970 -11010 2030 -11010 {
lab=cB14}
N 1970 -11030 2030 -11030 {
lab=cB15}
N 2040 -11020 2040 -10720 {bus=true
lab=cB[0..15]}
N 2040 -10720 2040 -10690 {bus=true
lab=cB[0..15]}
N 2340 -11420 2400 -11420 {
lab=rA0}
N 2750 -11420 2810 -11420 {
lab=rB0}
N 2750 -11440 2810 -11440 {
lab=rB1}
N 2750 -11460 2810 -11460 {
lab=rB2}
N 2750 -11480 2810 -11480 {
lab=rB3}
N 2750 -11500 2810 -11500 {
lab=rB4}
N 2750 -11520 2810 -11520 {
lab=rB5}
N 2750 -11540 2810 -11540 {
lab=rB6}
N 2750 -11560 2810 -11560 {
lab=rB7}
N 2750 -11580 2810 -11580 {
lab=rB8}
N 2750 -11600 2810 -11600 {
lab=rB9}
N 2750 -11620 2810 -11620 {
lab=rB10}
N 2750 -11640 2810 -11640 {
lab=rB11}
N 2750 -11660 2810 -11660 {
lab=rB12}
N 2750 -11680 2810 -11680 {
lab=rB13}
N 2750 -11700 2810 -11700 {
lab=rB14}
N 2750 -11720 2810 -11720 {
lab=rB15}
N 2190 -11420 2340 -11420 {
lab=rA0}
N 2190 -11460 2340 -11460 {
lab=rA2}
N 2190 -11480 2340 -11480 {
lab=rA3}
N 2190 -11500 2340 -11500 {
lab=rA4}
N 2190 -11520 2340 -11520 {
lab=rA5}
N 2190 -11540 2340 -11540 {
lab=rA6}
N 2190 -11560 2340 -11560 {
lab=rA7}
N 2190 -11580 2340 -11580 {
lab=rA8}
N 2190 -11620 2340 -11620 {
lab=rA10}
N 2190 -11600 2340 -11600 {
lab=rA9}
N 2190 -11640 2340 -11640 {
lab=rA11}
N 2190 -11660 2340 -11660 {
lab=rA12}
N 2190 -11680 2340 -11680 {
lab=rA13}
N 2190 -11700 2340 -11700 {
lab=rA14}
N 2190 -11720 2340 -11720 {
lab=rA15}
N 2190 -11440 2340 -11440 {
lab=rA1}
N 2340 -11440 2400 -11440 {
lab=rA1}
N 2340 -11460 2400 -11460 {
lab=rA2}
N 2340 -11480 2400 -11480 {
lab=rA3}
N 2340 -11500 2400 -11500 {
lab=rA4}
N 2340 -11520 2400 -11520 {
lab=rA5}
N 2340 -11540 2400 -11540 {
lab=rA6}
N 2340 -11560 2400 -11560 {
lab=rA7}
N 2340 -11580 2400 -11580 {
lab=rA8}
N 2340 -11600 2400 -11600 {
lab=rA9}
N 2340 -11620 2400 -11620 {
lab=rA10}
N 2340 -11640 2400 -11640 {
lab=rA11}
N 2340 -11660 2400 -11660 {
lab=rA12}
N 2340 -11680 2400 -11680 {
lab=rA13}
N 2340 -11700 2400 -11700 {
lab=rA14}
N 2340 -11720 2400 -11720 {
lab=rA15}
N 2180 -11710 2180 -11370 {
lab=rA[0..15]
bus=true}
N 2700 -11420 2750 -11420 {
lab=rB0}
N 2700 -11440 2750 -11440 {
lab=rB1}
N 2820 -11430 2820 -11370 {
lab=rB[0..15]
bus=true}
N 2700 -11460 2750 -11460 {
lab=rB2}
N 2700 -11480 2750 -11480 {
lab=rB3}
N 2700 -11500 2750 -11500 {
lab=rB4}
N 2700 -11520 2750 -11520 {
lab=rB5}
N 2700 -11540 2750 -11540 {
lab=rB6}
N 2700 -11560 2750 -11560 {
lab=rB7}
N 2700 -11580 2750 -11580 {
lab=rB8}
N 2700 -11600 2750 -11600 {
lab=rB9}
N 2700 -11620 2750 -11620 {
lab=rB10}
N 2700 -11640 2750 -11640 {
lab=rB11}
N 2700 -11660 2750 -11660 {
lab=rB12}
N 2700 -11680 2750 -11680 {
lab=rB13}
N 2700 -11700 2750 -11700 {
lab=rB14}
N 2700 -11720 2750 -11720 {
lab=rB15}
N 2820 -11710 2820 -11430 {
lab=rB[0..15]
bus=true}
N 2340 -10740 2400 -10740 {
lab=cA0}
N 2340 -10760 2400 -10760 {
lab=cA1}
N 2340 -10780 2400 -10780 {
lab=cA2}
N 2340 -10800 2400 -10800 {
lab=cA3}
N 2340 -10820 2400 -10820 {
lab=cA4}
N 2340 -10840 2400 -10840 {
lab=cA5}
N 2340 -10860 2400 -10860 {
lab=cA6}
N 2340 -10880 2400 -10880 {
lab=cA7}
N 2340 -10900 2400 -10900 {
lab=cA8}
N 2340 -10920 2400 -10920 {
lab=cA9}
N 2340 -10940 2400 -10940 {
lab=cA10}
N 2340 -10960 2400 -10960 {
lab=cA11}
N 2340 -10980 2400 -10980 {
lab=cA12}
N 2340 -11000 2400 -11000 {
lab=cA13}
N 2340 -11020 2400 -11020 {
lab=cA14}
N 2340 -11040 2400 -11040 {
lab=cA15}
N 2330 -11030 2330 -10730 {bus=true
lab=cA[0..15]}
N 2330 -10730 2330 -10700 {bus=true
lab=cA[0..15]}
N 2700 -10740 2760 -10740 {
lab=cB0}
N 2700 -10760 2760 -10760 {
lab=cB1}
N 2700 -10780 2760 -10780 {
lab=cB2}
N 2700 -10800 2760 -10800 {
lab=cB3}
N 2700 -10820 2760 -10820 {
lab=cB4}
N 2700 -10840 2760 -10840 {
lab=cB5}
N 2700 -10860 2760 -10860 {
lab=cB6}
N 2700 -10880 2760 -10880 {
lab=cB7}
N 2700 -10900 2760 -10900 {
lab=cB8}
N 2700 -10920 2760 -10920 {
lab=cB9}
N 2700 -10940 2760 -10940 {
lab=cB10}
N 2700 -10960 2760 -10960 {
lab=cB11}
N 2700 -10980 2760 -10980 {
lab=cB12}
N 2700 -11000 2760 -11000 {
lab=cB13}
N 2700 -11020 2760 -11020 {
lab=cB14}
N 2700 -11040 2760 -11040 {
lab=cB15}
N 2770 -11030 2770 -10730 {bus=true
lab=cB[0..15]}
N 2770 -10730 2770 -10700 {bus=true
lab=cB[0..15]}
N 3040 -11410 3100 -11410 {
lab=rA0}
N 3450 -11410 3510 -11410 {
lab=rB0}
N 3450 -11430 3510 -11430 {
lab=rB1}
N 3450 -11450 3510 -11450 {
lab=rB2}
N 3450 -11470 3510 -11470 {
lab=rB3}
N 3450 -11490 3510 -11490 {
lab=rB4}
N 3450 -11510 3510 -11510 {
lab=rB5}
N 3450 -11530 3510 -11530 {
lab=rB6}
N 3450 -11550 3510 -11550 {
lab=rB7}
N 3450 -11570 3510 -11570 {
lab=rB8}
N 3450 -11590 3510 -11590 {
lab=rB9}
N 3450 -11610 3510 -11610 {
lab=rB10}
N 3450 -11630 3510 -11630 {
lab=rB11}
N 3450 -11650 3510 -11650 {
lab=rB12}
N 3450 -11670 3510 -11670 {
lab=rB13}
N 3450 -11690 3510 -11690 {
lab=rB14}
N 3450 -11710 3510 -11710 {
lab=rB15}
N 2890 -11410 3040 -11410 {
lab=rA0}
N 2890 -11450 3040 -11450 {
lab=rA2}
N 2890 -11470 3040 -11470 {
lab=rA3}
N 2890 -11490 3040 -11490 {
lab=rA4}
N 2890 -11510 3040 -11510 {
lab=rA5}
N 2890 -11530 3040 -11530 {
lab=rA6}
N 2890 -11550 3040 -11550 {
lab=rA7}
N 2890 -11570 3040 -11570 {
lab=rA8}
N 2890 -11610 3040 -11610 {
lab=rA10}
N 2890 -11590 3040 -11590 {
lab=rA9}
N 2890 -11630 3040 -11630 {
lab=rA11}
N 2890 -11650 3040 -11650 {
lab=rA12}
N 2890 -11670 3040 -11670 {
lab=rA13}
N 2890 -11690 3040 -11690 {
lab=rA14}
N 2890 -11710 3040 -11710 {
lab=rA15}
N 2890 -11430 3040 -11430 {
lab=rA1}
N 3040 -11430 3100 -11430 {
lab=rA1}
N 3040 -11450 3100 -11450 {
lab=rA2}
N 3040 -11470 3100 -11470 {
lab=rA3}
N 3040 -11490 3100 -11490 {
lab=rA4}
N 3040 -11510 3100 -11510 {
lab=rA5}
N 3040 -11530 3100 -11530 {
lab=rA6}
N 3040 -11550 3100 -11550 {
lab=rA7}
N 3040 -11570 3100 -11570 {
lab=rA8}
N 3040 -11590 3100 -11590 {
lab=rA9}
N 3040 -11610 3100 -11610 {
lab=rA10}
N 3040 -11630 3100 -11630 {
lab=rA11}
N 3040 -11650 3100 -11650 {
lab=rA12}
N 3040 -11670 3100 -11670 {
lab=rA13}
N 3040 -11690 3100 -11690 {
lab=rA14}
N 3040 -11710 3100 -11710 {
lab=rA15}
N 2880 -11700 2880 -11360 {
lab=rA[0..15]
bus=true}
N 3400 -11410 3450 -11410 {
lab=rB0}
N 3400 -11430 3450 -11430 {
lab=rB1}
N 3520 -11420 3520 -11360 {
lab=rB[0..15]
bus=true}
N 3400 -11450 3450 -11450 {
lab=rB2}
N 3400 -11470 3450 -11470 {
lab=rB3}
N 3400 -11490 3450 -11490 {
lab=rB4}
N 3400 -11510 3450 -11510 {
lab=rB5}
N 3400 -11530 3450 -11530 {
lab=rB6}
N 3400 -11550 3450 -11550 {
lab=rB7}
N 3400 -11570 3450 -11570 {
lab=rB8}
N 3400 -11590 3450 -11590 {
lab=rB9}
N 3400 -11610 3450 -11610 {
lab=rB10}
N 3400 -11630 3450 -11630 {
lab=rB11}
N 3400 -11650 3450 -11650 {
lab=rB12}
N 3400 -11670 3450 -11670 {
lab=rB13}
N 3400 -11690 3450 -11690 {
lab=rB14}
N 3400 -11710 3450 -11710 {
lab=rB15}
N 3520 -11700 3520 -11420 {
lab=rB[0..15]
bus=true}
N 3040 -10730 3100 -10730 {
lab=cA0}
N 3040 -10750 3100 -10750 {
lab=cA1}
N 3040 -10770 3100 -10770 {
lab=cA2}
N 3040 -10790 3100 -10790 {
lab=cA3}
N 3040 -10810 3100 -10810 {
lab=cA4}
N 3040 -10830 3100 -10830 {
lab=cA5}
N 3040 -10850 3100 -10850 {
lab=cA6}
N 3040 -10870 3100 -10870 {
lab=cA7}
N 3040 -10890 3100 -10890 {
lab=cA8}
N 3040 -10910 3100 -10910 {
lab=cA9}
N 3040 -10930 3100 -10930 {
lab=cA10}
N 3040 -10950 3100 -10950 {
lab=cA11}
N 3040 -10970 3100 -10970 {
lab=cA12}
N 3040 -10990 3100 -10990 {
lab=cA13}
N 3040 -11010 3100 -11010 {
lab=cA14}
N 3040 -11030 3100 -11030 {
lab=cA15}
N 3030 -11020 3030 -10720 {bus=true
lab=cA[0..15]}
N 3030 -10720 3030 -10690 {bus=true
lab=cA[0..15]}
N 3400 -10730 3460 -10730 {
lab=cB0}
N 3400 -10750 3460 -10750 {
lab=cB1}
N 3400 -10770 3460 -10770 {
lab=cB2}
N 3400 -10790 3460 -10790 {
lab=cB3}
N 3400 -10810 3460 -10810 {
lab=cB4}
N 3400 -10830 3460 -10830 {
lab=cB5}
N 3400 -10850 3460 -10850 {
lab=cB6}
N 3400 -10870 3460 -10870 {
lab=cB7}
N 3400 -10890 3460 -10890 {
lab=cB8}
N 3400 -10910 3460 -10910 {
lab=cB9}
N 3400 -10930 3460 -10930 {
lab=cB10}
N 3400 -10950 3460 -10950 {
lab=cB11}
N 3400 -10970 3460 -10970 {
lab=cB12}
N 3400 -10990 3460 -10990 {
lab=cB13}
N 3400 -11010 3460 -11010 {
lab=cB14}
N 3400 -11030 3460 -11030 {
lab=cB15}
N 3470 -11020 3470 -10720 {bus=true
lab=cB[0..15]}
N 3470 -10720 3470 -10690 {bus=true
lab=cB[0..15]}
N 3750 -11410 3810 -11410 {
lab=rA0}
N 4160 -11410 4220 -11410 {
lab=rB0}
N 4160 -11430 4220 -11430 {
lab=rB1}
N 4160 -11450 4220 -11450 {
lab=rB2}
N 4160 -11470 4220 -11470 {
lab=rB3}
N 4160 -11490 4220 -11490 {
lab=rB4}
N 4160 -11510 4220 -11510 {
lab=rB5}
N 4160 -11530 4220 -11530 {
lab=rB6}
N 4160 -11550 4220 -11550 {
lab=rB7}
N 4160 -11570 4220 -11570 {
lab=rB8}
N 4160 -11590 4220 -11590 {
lab=rB9}
N 4160 -11610 4220 -11610 {
lab=rB10}
N 4160 -11630 4220 -11630 {
lab=rB11}
N 4160 -11650 4220 -11650 {
lab=rB12}
N 4160 -11670 4220 -11670 {
lab=rB13}
N 4160 -11690 4220 -11690 {
lab=rB14}
N 4160 -11710 4220 -11710 {
lab=rB15}
N 3600 -11410 3750 -11410 {
lab=rA0}
N 3600 -11450 3750 -11450 {
lab=rA2}
N 3600 -11470 3750 -11470 {
lab=rA3}
N 3600 -11490 3750 -11490 {
lab=rA4}
N 3600 -11510 3750 -11510 {
lab=rA5}
N 3600 -11530 3750 -11530 {
lab=rA6}
N 3600 -11550 3750 -11550 {
lab=rA7}
N 3600 -11570 3750 -11570 {
lab=rA8}
N 3600 -11610 3750 -11610 {
lab=rA10}
N 3600 -11590 3750 -11590 {
lab=rA9}
N 3600 -11630 3750 -11630 {
lab=rA11}
N 3600 -11650 3750 -11650 {
lab=rA12}
N 3600 -11670 3750 -11670 {
lab=rA13}
N 3600 -11690 3750 -11690 {
lab=rA14}
N 3600 -11710 3750 -11710 {
lab=rA15}
N 3600 -11430 3750 -11430 {
lab=rA1}
N 3750 -11430 3810 -11430 {
lab=rA1}
N 3750 -11450 3810 -11450 {
lab=rA2}
N 3750 -11470 3810 -11470 {
lab=rA3}
N 3750 -11490 3810 -11490 {
lab=rA4}
N 3750 -11510 3810 -11510 {
lab=rA5}
N 3750 -11530 3810 -11530 {
lab=rA6}
N 3750 -11550 3810 -11550 {
lab=rA7}
N 3750 -11570 3810 -11570 {
lab=rA8}
N 3750 -11590 3810 -11590 {
lab=rA9}
N 3750 -11610 3810 -11610 {
lab=rA10}
N 3750 -11630 3810 -11630 {
lab=rA11}
N 3750 -11650 3810 -11650 {
lab=rA12}
N 3750 -11670 3810 -11670 {
lab=rA13}
N 3750 -11690 3810 -11690 {
lab=rA14}
N 3750 -11710 3810 -11710 {
lab=rA15}
N 3590 -11700 3590 -11360 {
lab=rA[0..15]
bus=true}
N 4110 -11410 4160 -11410 {
lab=rB0}
N 4110 -11430 4160 -11430 {
lab=rB1}
N 4230 -11420 4230 -11360 {
lab=rB[0..15]
bus=true}
N 4110 -11450 4160 -11450 {
lab=rB2}
N 4110 -11470 4160 -11470 {
lab=rB3}
N 4110 -11490 4160 -11490 {
lab=rB4}
N 4110 -11510 4160 -11510 {
lab=rB5}
N 4110 -11530 4160 -11530 {
lab=rB6}
N 4110 -11550 4160 -11550 {
lab=rB7}
N 4110 -11570 4160 -11570 {
lab=rB8}
N 4110 -11590 4160 -11590 {
lab=rB9}
N 4110 -11610 4160 -11610 {
lab=rB10}
N 4110 -11630 4160 -11630 {
lab=rB11}
N 4110 -11650 4160 -11650 {
lab=rB12}
N 4110 -11670 4160 -11670 {
lab=rB13}
N 4110 -11690 4160 -11690 {
lab=rB14}
N 4110 -11710 4160 -11710 {
lab=rB15}
N 4230 -11700 4230 -11420 {
lab=rB[0..15]
bus=true}
N 3750 -10730 3810 -10730 {
lab=cA0}
N 3750 -10750 3810 -10750 {
lab=cA1}
N 3750 -10770 3810 -10770 {
lab=cA2}
N 3750 -10790 3810 -10790 {
lab=cA3}
N 3750 -10810 3810 -10810 {
lab=cA4}
N 3750 -10830 3810 -10830 {
lab=cA5}
N 3750 -10850 3810 -10850 {
lab=cA6}
N 3750 -10870 3810 -10870 {
lab=cA7}
N 3750 -10890 3810 -10890 {
lab=cA8}
N 3750 -10910 3810 -10910 {
lab=cA9}
N 3750 -10930 3810 -10930 {
lab=cA10}
N 3750 -10950 3810 -10950 {
lab=cA11}
N 3750 -10970 3810 -10970 {
lab=cA12}
N 3750 -10990 3810 -10990 {
lab=cA13}
N 3750 -11010 3810 -11010 {
lab=cA14}
N 3750 -11030 3810 -11030 {
lab=cA15}
N 3740 -11020 3740 -10720 {bus=true
lab=cA[0..15]}
N 3740 -10720 3740 -10690 {bus=true
lab=cA[0..15]}
N 4110 -10730 4170 -10730 {
lab=cB0}
N 4110 -10750 4170 -10750 {
lab=cB1}
N 4110 -10770 4170 -10770 {
lab=cB2}
N 4110 -10790 4170 -10790 {
lab=cB3}
N 4110 -10810 4170 -10810 {
lab=cB4}
N 4110 -10830 4170 -10830 {
lab=cB5}
N 4110 -10850 4170 -10850 {
lab=cB6}
N 4110 -10870 4170 -10870 {
lab=cB7}
N 4110 -10890 4170 -10890 {
lab=cB8}
N 4110 -10910 4170 -10910 {
lab=cB9}
N 4110 -10930 4170 -10930 {
lab=cB10}
N 4110 -10950 4170 -10950 {
lab=cB11}
N 4110 -10970 4170 -10970 {
lab=cB12}
N 4110 -10990 4170 -10990 {
lab=cB13}
N 4110 -11010 4170 -11010 {
lab=cB14}
N 4110 -11030 4170 -11030 {
lab=cB15}
N 4180 -11020 4180 -10720 {bus=true
lab=cB[0..15]}
N 4180 -10720 4180 -10690 {bus=true
lab=cB[0..15]}
N 2340 -12000 2400 -12000 {
lab=col3_sel}
N 2340 -12020 2400 -12020 {
lab=row5_sel}
N 2340 -11780 2400 -11780 {
lab=Vcplus}
N 2340 -11800 2400 -11800 {
lab=Vcminus}
N 2340 -11820 2400 -11820 {
lab=Vref}
N 2340 -11840 2400 -11840 {
lab=Vref_comp}
N 2340 -11860 2400 -11860 {
lab=RISC_CLK}
N 2340 -11920 2400 -11920 {
lab=SAMPLE}
N 2340 -11900 2400 -11900 {
lab=Vrminus}
N 2340 -11880 2400 -11880 {
lab=Vrplus}
N 2340 -11960 2400 -11960 {
lab=WR}
N 2340 -11980 2400 -11980 {
lab=Vgnr}
N 2340 -11940 2400 -11940 {
lab=Vgpr}
N 3040 -11990 3100 -11990 {
lab=col4_sel}
N 3040 -12010 3100 -12010 {
lab=row5_sel}
N 3040 -11770 3100 -11770 {
lab=Vcplus}
N 3040 -11790 3100 -11790 {
lab=Vcminus}
N 3040 -11810 3100 -11810 {
lab=Vref}
N 3040 -11830 3100 -11830 {
lab=Vref_comp}
N 3040 -11850 3100 -11850 {
lab=RISC_CLK}
N 3040 -11910 3100 -11910 {
lab=SAMPLE}
N 3040 -11890 3100 -11890 {
lab=Vrminus}
N 3040 -11870 3100 -11870 {
lab=Vrplus}
N 3040 -11950 3100 -11950 {
lab=WR}
N 3040 -11970 3100 -11970 {
lab=Vgnr}
N 3040 -11930 3100 -11930 {
lab=Vgpr}
N 3750 -11990 3810 -11990 {
lab=col5_sel}
N 3750 -12010 3810 -12010 {
lab=row5_sel}
N 3750 -11770 3810 -11770 {
lab=Vcplus}
N 3750 -11790 3810 -11790 {
lab=Vcminus}
N 3750 -11810 3810 -11810 {
lab=Vref}
N 3750 -11830 3810 -11830 {
lab=Vref_comp}
N 3750 -11850 3810 -11850 {
lab=RISC_CLK}
N 3750 -11910 3810 -11910 {
lab=SAMPLE}
N 3750 -11890 3810 -11890 {
lab=Vrminus}
N 3750 -11870 3810 -11870 {
lab=Vrplus}
N 3750 -11950 3810 -11950 {
lab=WR}
N 3750 -11970 3810 -11970 {
lab=Vgnr}
N 3750 -11930 3810 -11930 {
lab=Vgpr}
N 190 -13490 250 -13490 {
lab=rA0}
N 600 -13490 660 -13490 {
lab=rB0}
N 600 -13510 660 -13510 {
lab=rB1}
N 600 -13530 660 -13530 {
lab=rB2}
N 600 -13550 660 -13550 {
lab=rB3}
N 600 -13570 660 -13570 {
lab=rB4}
N 600 -13590 660 -13590 {
lab=rB5}
N 600 -13610 660 -13610 {
lab=rB6}
N 600 -13630 660 -13630 {
lab=rB7}
N 600 -13650 660 -13650 {
lab=rB8}
N 600 -13670 660 -13670 {
lab=rB9}
N 600 -13690 660 -13690 {
lab=rB10}
N 600 -13710 660 -13710 {
lab=rB11}
N 600 -13730 660 -13730 {
lab=rB12}
N 600 -13750 660 -13750 {
lab=rB13}
N 600 -13770 660 -13770 {
lab=rB14}
N 600 -13790 660 -13790 {
lab=rB15}
N 190 -13150 250 -13150 {
lab=WL0}
N 190 -13170 250 -13170 {
lab=WL1}
N 190 -13190 250 -13190 {
lab=WL2}
N 190 -13210 250 -13210 {
lab=WL3}
N 190 -13230 250 -13230 {
lab=WL4}
N 190 -13250 250 -13250 {
lab=WL5}
N 190 -13270 250 -13270 {
lab=WL6}
N 190 -13290 250 -13290 {
lab=WL7}
N 190 -13310 250 -13310 {
lab=WL8}
N 190 -13330 250 -13330 {
lab=WL9}
N 190 -13350 250 -13350 {
lab=WL10}
N 190 -13370 250 -13370 {
lab=WL11}
N 190 -13390 250 -13390 {
lab=WL12}
N 190 -13410 250 -13410 {
lab=WL13}
N 190 -13430 250 -13430 {
lab=WL14}
N 190 -13450 250 -13450 {
lab=WL15}
N 190 -12810 250 -12810 {
lab=cA0}
N 190 -12830 250 -12830 {
lab=cA1}
N 190 -12850 250 -12850 {
lab=cA2}
N 190 -12870 250 -12870 {
lab=cA3}
N 190 -12890 250 -12890 {
lab=cA4}
N 190 -12910 250 -12910 {
lab=cA5}
N 190 -12930 250 -12930 {
lab=cA6}
N 190 -12950 250 -12950 {
lab=cA7}
N 190 -12970 250 -12970 {
lab=cA8}
N 190 -12990 250 -12990 {
lab=cA9}
N 190 -13010 250 -13010 {
lab=cA10}
N 190 -13030 250 -13030 {
lab=cA11}
N 190 -13050 250 -13050 {
lab=cA12}
N 190 -13070 250 -13070 {
lab=cA13}
N 190 -13090 250 -13090 {
lab=cA14}
N 190 -13110 250 -13110 {
lab=cA15}
N 190 -14070 250 -14070 {
lab=col0_sel}
N 190 -14090 250 -14090 {
lab=row6_sel}
N 190 -14030 250 -14030 {
lab=WR}
N 190 -14050 250 -14050 {
lab=Vgnr}
N 190 -14010 250 -14010 {
lab=Vgpr}
N 190 -13850 250 -13850 {
lab=Vcplus}
N 190 -13870 250 -13870 {
lab=Vcminus}
N 190 -13890 250 -13890 {
lab=Vref}
N 190 -13910 250 -13910 {
lab=Vref_comp}
N 190 -13930 250 -13930 {
lab=RISC_CLK}
N 550 -14030 610 -14030 {
lab=vssd1}
N 550 -14050 610 -14050 {
lab=vdda1}
N 550 -14070 610 -14070 {
lab=vccd1}
N 550 -14090 610 -14090 {
lab=latch_high0}
N 1970 -14080 2030 -14080 {
lab=latch_high2}
N 2700 -14030 2760 -14030 {
lab=vssd1}
N 2700 -14050 2760 -14050 {
lab=vdda1}
N 2700 -14070 2760 -14070 {
lab=vccd1}
N 2700 -14090 2760 -14090 {
lab=latch_high3}
N 3400 -14020 3460 -14020 {
lab=vssd1}
N 3400 -14040 3460 -14040 {
lab=vdda1}
N 3400 -14060 3460 -14060 {
lab=vccd1}
N 3400 -14080 3460 -14080 {
lab=latch_high4}
N 4110 -14020 4170 -14020 {
lab=vssd1}
N 4110 -14040 4170 -14040 {
lab=vdda1}
N 4110 -14060 4170 -14060 {
lab=vccd1}
N 4110 -14080 4170 -14080 {
lab=latch_high5}
N 130 -13150 190 -13150 {
lab=WL0}
N 130 -13170 190 -13170 {
lab=WL1}
N 130 -13190 190 -13190 {
lab=WL2}
N 130 -13210 190 -13210 {
lab=WL3}
N 130 -13230 190 -13230 {
lab=WL4}
N 130 -13250 190 -13250 {
lab=WL5}
N 130 -13270 190 -13270 {
lab=WL6}
N 130 -13290 190 -13290 {
lab=WL7}
N 130 -13310 190 -13310 {
lab=WL8}
N 130 -13330 190 -13330 {
lab=WL9}
N 130 -13350 190 -13350 {
lab=WL10}
N 130 -13370 190 -13370 {
lab=WL11}
N 130 -13390 190 -13390 {
lab=WL12}
N 130 -13410 190 -13410 {
lab=WL13}
N 130 -13430 190 -13430 {
lab=WL14}
N 130 -13450 190 -13450 {
lab=WL15}
N 70 -13150 130 -13150 {
lab=WL0}
N 70 -13170 130 -13170 {
lab=WL1}
N 70 -13190 130 -13190 {
lab=WL2}
N 70 -13210 130 -13210 {
lab=WL3}
N 70 -13230 130 -13230 {
lab=WL4}
N 70 -13250 130 -13250 {
lab=WL5}
N 70 -13270 130 -13270 {
lab=WL6}
N 70 -13290 130 -13290 {
lab=WL7}
N 70 -13310 130 -13310 {
lab=WL8}
N 70 -13330 130 -13330 {
lab=WL9}
N 70 -13350 130 -13350 {
lab=WL10}
N 70 -13370 130 -13370 {
lab=WL11}
N 70 -13390 130 -13390 {
lab=WL12}
N 70 -13410 130 -13410 {
lab=WL13}
N 70 -13430 130 -13430 {
lab=WL14}
N 70 -13450 130 -13450 {
lab=WL15}
N 60 -13440 60 -13140 {bus=true
lab=WL[0..15]}
N 60 -13140 60 -13110 {bus=true
lab=WL[0..15]}
N 910 -13150 970 -13150 {
lab=WL0}
N 910 -13170 970 -13170 {
lab=WL1}
N 910 -13190 970 -13190 {
lab=WL2}
N 910 -13210 970 -13210 {
lab=WL3}
N 910 -13230 970 -13230 {
lab=WL4}
N 910 -13250 970 -13250 {
lab=WL5}
N 910 -13270 970 -13270 {
lab=WL6}
N 910 -13290 970 -13290 {
lab=WL7}
N 910 -13310 970 -13310 {
lab=WL8}
N 910 -13330 970 -13330 {
lab=WL9}
N 910 -13350 970 -13350 {
lab=WL10}
N 910 -13370 970 -13370 {
lab=WL11}
N 910 -13390 970 -13390 {
lab=WL12}
N 910 -13410 970 -13410 {
lab=WL13}
N 910 -13430 970 -13430 {
lab=WL14}
N 910 -13450 970 -13450 {
lab=WL15}
N 850 -13150 910 -13150 {
lab=WL0}
N 850 -13170 910 -13170 {
lab=WL1}
N 850 -13190 910 -13190 {
lab=WL2}
N 850 -13210 910 -13210 {
lab=WL3}
N 850 -13230 910 -13230 {
lab=WL4}
N 850 -13250 910 -13250 {
lab=WL5}
N 850 -13270 910 -13270 {
lab=WL6}
N 850 -13290 910 -13290 {
lab=WL7}
N 850 -13310 910 -13310 {
lab=WL8}
N 850 -13330 910 -13330 {
lab=WL9}
N 850 -13350 910 -13350 {
lab=WL10}
N 850 -13370 910 -13370 {
lab=WL11}
N 850 -13390 910 -13390 {
lab=WL12}
N 850 -13410 910 -13410 {
lab=WL13}
N 850 -13430 910 -13430 {
lab=WL14}
N 850 -13450 910 -13450 {
lab=WL15}
N 790 -13150 850 -13150 {
lab=WL0}
N 790 -13170 850 -13170 {
lab=WL1}
N 790 -13190 850 -13190 {
lab=WL2}
N 790 -13210 850 -13210 {
lab=WL3}
N 790 -13230 850 -13230 {
lab=WL4}
N 790 -13250 850 -13250 {
lab=WL5}
N 790 -13270 850 -13270 {
lab=WL6}
N 790 -13290 850 -13290 {
lab=WL7}
N 790 -13310 850 -13310 {
lab=WL8}
N 790 -13330 850 -13330 {
lab=WL9}
N 790 -13350 850 -13350 {
lab=WL10}
N 790 -13370 850 -13370 {
lab=WL11}
N 790 -13390 850 -13390 {
lab=WL12}
N 790 -13410 850 -13410 {
lab=WL13}
N 790 -13430 850 -13430 {
lab=WL14}
N 790 -13450 850 -13450 {
lab=WL15}
N 780 -13440 780 -13140 {bus=true
lab=WL[0..15]}
N 780 -13140 780 -13110 {bus=true
lab=WL[0..15]}
N 1610 -13140 1670 -13140 {
lab=WL0}
N 1610 -13160 1670 -13160 {
lab=WL1}
N 1610 -13180 1670 -13180 {
lab=WL2}
N 1610 -13200 1670 -13200 {
lab=WL3}
N 1610 -13220 1670 -13220 {
lab=WL4}
N 1610 -13240 1670 -13240 {
lab=WL5}
N 1610 -13260 1670 -13260 {
lab=WL6}
N 1610 -13280 1670 -13280 {
lab=WL7}
N 1610 -13300 1670 -13300 {
lab=WL8}
N 1610 -13320 1670 -13320 {
lab=WL9}
N 1610 -13340 1670 -13340 {
lab=WL10}
N 1610 -13360 1670 -13360 {
lab=WL11}
N 1610 -13380 1670 -13380 {
lab=WL12}
N 1610 -13400 1670 -13400 {
lab=WL13}
N 1610 -13420 1670 -13420 {
lab=WL14}
N 1610 -13440 1670 -13440 {
lab=WL15}
N 1550 -13140 1610 -13140 {
lab=WL0}
N 1550 -13160 1610 -13160 {
lab=WL1}
N 1550 -13180 1610 -13180 {
lab=WL2}
N 1550 -13200 1610 -13200 {
lab=WL3}
N 1550 -13220 1610 -13220 {
lab=WL4}
N 1550 -13240 1610 -13240 {
lab=WL5}
N 1550 -13260 1610 -13260 {
lab=WL6}
N 1550 -13280 1610 -13280 {
lab=WL7}
N 1550 -13300 1610 -13300 {
lab=WL8}
N 1550 -13320 1610 -13320 {
lab=WL9}
N 1550 -13340 1610 -13340 {
lab=WL10}
N 1550 -13360 1610 -13360 {
lab=WL11}
N 1550 -13380 1610 -13380 {
lab=WL12}
N 1550 -13400 1610 -13400 {
lab=WL13}
N 1550 -13420 1610 -13420 {
lab=WL14}
N 1550 -13440 1610 -13440 {
lab=WL15}
N 1490 -13140 1550 -13140 {
lab=WL0}
N 1490 -13160 1550 -13160 {
lab=WL1}
N 1490 -13180 1550 -13180 {
lab=WL2}
N 1490 -13200 1550 -13200 {
lab=WL3}
N 1490 -13220 1550 -13220 {
lab=WL4}
N 1490 -13240 1550 -13240 {
lab=WL5}
N 1490 -13260 1550 -13260 {
lab=WL6}
N 1490 -13280 1550 -13280 {
lab=WL7}
N 1490 -13300 1550 -13300 {
lab=WL8}
N 1490 -13320 1550 -13320 {
lab=WL9}
N 1490 -13340 1550 -13340 {
lab=WL10}
N 1490 -13360 1550 -13360 {
lab=WL11}
N 1490 -13380 1550 -13380 {
lab=WL12}
N 1490 -13400 1550 -13400 {
lab=WL13}
N 1490 -13420 1550 -13420 {
lab=WL14}
N 1490 -13440 1550 -13440 {
lab=WL15}
N 1480 -13430 1480 -13130 {bus=true
lab=WL[0..15]}
N 1480 -13130 1480 -13100 {bus=true
lab=WL[0..15]}
N 2340 -13150 2400 -13150 {
lab=WL0}
N 2340 -13170 2400 -13170 {
lab=WL1}
N 2340 -13190 2400 -13190 {
lab=WL2}
N 2340 -13210 2400 -13210 {
lab=WL3}
N 2340 -13230 2400 -13230 {
lab=WL4}
N 2340 -13250 2400 -13250 {
lab=WL5}
N 2340 -13270 2400 -13270 {
lab=WL6}
N 2340 -13290 2400 -13290 {
lab=WL7}
N 2340 -13310 2400 -13310 {
lab=WL8}
N 2340 -13330 2400 -13330 {
lab=WL9}
N 2340 -13350 2400 -13350 {
lab=WL10}
N 2340 -13370 2400 -13370 {
lab=WL11}
N 2340 -13390 2400 -13390 {
lab=WL12}
N 2340 -13410 2400 -13410 {
lab=WL13}
N 2340 -13430 2400 -13430 {
lab=WL14}
N 2340 -13450 2400 -13450 {
lab=WL15}
N 2280 -13150 2340 -13150 {
lab=WL0}
N 2280 -13170 2340 -13170 {
lab=WL1}
N 2280 -13190 2340 -13190 {
lab=WL2}
N 2280 -13210 2340 -13210 {
lab=WL3}
N 2280 -13230 2340 -13230 {
lab=WL4}
N 2280 -13250 2340 -13250 {
lab=WL5}
N 2280 -13270 2340 -13270 {
lab=WL6}
N 2280 -13290 2340 -13290 {
lab=WL7}
N 2280 -13310 2340 -13310 {
lab=WL8}
N 2280 -13330 2340 -13330 {
lab=WL9}
N 2280 -13350 2340 -13350 {
lab=WL10}
N 2280 -13370 2340 -13370 {
lab=WL11}
N 2280 -13390 2340 -13390 {
lab=WL12}
N 2280 -13410 2340 -13410 {
lab=WL13}
N 2280 -13430 2340 -13430 {
lab=WL14}
N 2280 -13450 2340 -13450 {
lab=WL15}
N 2220 -13150 2280 -13150 {
lab=WL0}
N 2220 -13170 2280 -13170 {
lab=WL1}
N 2220 -13190 2280 -13190 {
lab=WL2}
N 2220 -13210 2280 -13210 {
lab=WL3}
N 2220 -13230 2280 -13230 {
lab=WL4}
N 2220 -13250 2280 -13250 {
lab=WL5}
N 2220 -13270 2280 -13270 {
lab=WL6}
N 2220 -13290 2280 -13290 {
lab=WL7}
N 2220 -13310 2280 -13310 {
lab=WL8}
N 2220 -13330 2280 -13330 {
lab=WL9}
N 2220 -13350 2280 -13350 {
lab=WL10}
N 2220 -13370 2280 -13370 {
lab=WL11}
N 2220 -13390 2280 -13390 {
lab=WL12}
N 2220 -13410 2280 -13410 {
lab=WL13}
N 2220 -13430 2280 -13430 {
lab=WL14}
N 2220 -13450 2280 -13450 {
lab=WL15}
N 2210 -13440 2210 -13140 {bus=true
lab=WL[0..15]}
N 2210 -13140 2210 -13110 {bus=true
lab=WL[0..15]}
N 3040 -13140 3100 -13140 {
lab=WL0}
N 3040 -13160 3100 -13160 {
lab=WL1}
N 3040 -13180 3100 -13180 {
lab=WL2}
N 3040 -13200 3100 -13200 {
lab=WL3}
N 3040 -13220 3100 -13220 {
lab=WL4}
N 3040 -13240 3100 -13240 {
lab=WL5}
N 3040 -13260 3100 -13260 {
lab=WL6}
N 3040 -13280 3100 -13280 {
lab=WL7}
N 3040 -13300 3100 -13300 {
lab=WL8}
N 3040 -13320 3100 -13320 {
lab=WL9}
N 3040 -13340 3100 -13340 {
lab=WL10}
N 3040 -13360 3100 -13360 {
lab=WL11}
N 3040 -13380 3100 -13380 {
lab=WL12}
N 3040 -13400 3100 -13400 {
lab=WL13}
N 3040 -13420 3100 -13420 {
lab=WL14}
N 3040 -13440 3100 -13440 {
lab=WL15}
N 2980 -13140 3040 -13140 {
lab=WL0}
N 2980 -13160 3040 -13160 {
lab=WL1}
N 2980 -13180 3040 -13180 {
lab=WL2}
N 2980 -13200 3040 -13200 {
lab=WL3}
N 2980 -13220 3040 -13220 {
lab=WL4}
N 2980 -13240 3040 -13240 {
lab=WL5}
N 2980 -13260 3040 -13260 {
lab=WL6}
N 2980 -13280 3040 -13280 {
lab=WL7}
N 2980 -13300 3040 -13300 {
lab=WL8}
N 2980 -13320 3040 -13320 {
lab=WL9}
N 2980 -13340 3040 -13340 {
lab=WL10}
N 2980 -13360 3040 -13360 {
lab=WL11}
N 2980 -13380 3040 -13380 {
lab=WL12}
N 2980 -13400 3040 -13400 {
lab=WL13}
N 2980 -13420 3040 -13420 {
lab=WL14}
N 2980 -13440 3040 -13440 {
lab=WL15}
N 2920 -13140 2980 -13140 {
lab=WL0}
N 2920 -13160 2980 -13160 {
lab=WL1}
N 2920 -13180 2980 -13180 {
lab=WL2}
N 2920 -13200 2980 -13200 {
lab=WL3}
N 2920 -13220 2980 -13220 {
lab=WL4}
N 2920 -13240 2980 -13240 {
lab=WL5}
N 2920 -13260 2980 -13260 {
lab=WL6}
N 2920 -13280 2980 -13280 {
lab=WL7}
N 2920 -13300 2980 -13300 {
lab=WL8}
N 2920 -13320 2980 -13320 {
lab=WL9}
N 2920 -13340 2980 -13340 {
lab=WL10}
N 2920 -13360 2980 -13360 {
lab=WL11}
N 2920 -13380 2980 -13380 {
lab=WL12}
N 2920 -13400 2980 -13400 {
lab=WL13}
N 2920 -13420 2980 -13420 {
lab=WL14}
N 2920 -13440 2980 -13440 {
lab=WL15}
N 2910 -13430 2910 -13130 {bus=true
lab=WL[0..15]}
N 2910 -13130 2910 -13100 {bus=true
lab=WL[0..15]}
N 3750 -13140 3810 -13140 {
lab=WL0}
N 3750 -13160 3810 -13160 {
lab=WL1}
N 3750 -13180 3810 -13180 {
lab=WL2}
N 3750 -13200 3810 -13200 {
lab=WL3}
N 3750 -13220 3810 -13220 {
lab=WL4}
N 3750 -13240 3810 -13240 {
lab=WL5}
N 3750 -13260 3810 -13260 {
lab=WL6}
N 3750 -13280 3810 -13280 {
lab=WL7}
N 3750 -13300 3810 -13300 {
lab=WL8}
N 3750 -13320 3810 -13320 {
lab=WL9}
N 3750 -13340 3810 -13340 {
lab=WL10}
N 3750 -13360 3810 -13360 {
lab=WL11}
N 3750 -13380 3810 -13380 {
lab=WL12}
N 3750 -13400 3810 -13400 {
lab=WL13}
N 3750 -13420 3810 -13420 {
lab=WL14}
N 3750 -13440 3810 -13440 {
lab=WL15}
N 3690 -13140 3750 -13140 {
lab=WL0}
N 3690 -13160 3750 -13160 {
lab=WL1}
N 3690 -13180 3750 -13180 {
lab=WL2}
N 3690 -13200 3750 -13200 {
lab=WL3}
N 3690 -13220 3750 -13220 {
lab=WL4}
N 3690 -13240 3750 -13240 {
lab=WL5}
N 3690 -13260 3750 -13260 {
lab=WL6}
N 3690 -13280 3750 -13280 {
lab=WL7}
N 3690 -13300 3750 -13300 {
lab=WL8}
N 3690 -13320 3750 -13320 {
lab=WL9}
N 3690 -13340 3750 -13340 {
lab=WL10}
N 3690 -13360 3750 -13360 {
lab=WL11}
N 3690 -13380 3750 -13380 {
lab=WL12}
N 3690 -13400 3750 -13400 {
lab=WL13}
N 3690 -13420 3750 -13420 {
lab=WL14}
N 3690 -13440 3750 -13440 {
lab=WL15}
N 3630 -13140 3690 -13140 {
lab=WL0}
N 3630 -13160 3690 -13160 {
lab=WL1}
N 3630 -13180 3690 -13180 {
lab=WL2}
N 3630 -13200 3690 -13200 {
lab=WL3}
N 3630 -13220 3690 -13220 {
lab=WL4}
N 3630 -13240 3690 -13240 {
lab=WL5}
N 3630 -13260 3690 -13260 {
lab=WL6}
N 3630 -13280 3690 -13280 {
lab=WL7}
N 3630 -13300 3690 -13300 {
lab=WL8}
N 3630 -13320 3690 -13320 {
lab=WL9}
N 3630 -13340 3690 -13340 {
lab=WL10}
N 3630 -13360 3690 -13360 {
lab=WL11}
N 3630 -13380 3690 -13380 {
lab=WL12}
N 3630 -13400 3690 -13400 {
lab=WL13}
N 3630 -13420 3690 -13420 {
lab=WL14}
N 3630 -13440 3690 -13440 {
lab=WL15}
N 3620 -13430 3620 -13130 {bus=true
lab=WL[0..15]}
N 3620 -13130 3620 -13100 {bus=true
lab=WL[0..15]}
N 40 -13490 190 -13490 {
lab=rA0}
N 40 -13530 190 -13530 {
lab=rA2}
N 40 -13550 190 -13550 {
lab=rA3}
N 40 -13570 190 -13570 {
lab=rA4}
N 40 -13590 190 -13590 {
lab=rA5}
N 40 -13610 190 -13610 {
lab=rA6}
N 40 -13630 190 -13630 {
lab=rA7}
N 40 -13650 190 -13650 {
lab=rA8}
N 40 -13690 190 -13690 {
lab=rA10}
N 40 -13670 190 -13670 {
lab=rA9}
N 40 -13710 190 -13710 {
lab=rA11}
N 40 -13730 190 -13730 {
lab=rA12}
N 40 -13750 190 -13750 {
lab=rA13}
N 40 -13770 190 -13770 {
lab=rA14}
N 40 -13790 190 -13790 {
lab=rA15}
N 190 -13990 250 -13990 {
lab=SAMPLE}
N 190 -13970 250 -13970 {
lab=Vrminus}
N 190 -13950 250 -13950 {
lab=Vrplus}
N 40 -13510 190 -13510 {
lab=rA1}
N 190 -13510 250 -13510 {
lab=rA1}
N 190 -13530 250 -13530 {
lab=rA2}
N 190 -13550 250 -13550 {
lab=rA3}
N 190 -13570 250 -13570 {
lab=rA4}
N 190 -13590 250 -13590 {
lab=rA5}
N 190 -13610 250 -13610 {
lab=rA6}
N 190 -13630 250 -13630 {
lab=rA7}
N 190 -13650 250 -13650 {
lab=rA8}
N 190 -13670 250 -13670 {
lab=rA9}
N 190 -13690 250 -13690 {
lab=rA10}
N 190 -13710 250 -13710 {
lab=rA11}
N 190 -13730 250 -13730 {
lab=rA12}
N 190 -13750 250 -13750 {
lab=rA13}
N 190 -13770 250 -13770 {
lab=rA14}
N 190 -13790 250 -13790 {
lab=rA15}
N 30 -13780 30 -13440 {
lab=rA[0..15]
bus=true}
N 550 -13490 600 -13490 {
lab=rB0}
N 550 -13510 600 -13510 {
lab=rB1}
N 670 -13500 670 -13440 {
lab=rB[0..15]
bus=true}
N 550 -13530 600 -13530 {
lab=rB2}
N 550 -13550 600 -13550 {
lab=rB3}
N 550 -13570 600 -13570 {
lab=rB4}
N 550 -13590 600 -13590 {
lab=rB5}
N 550 -13610 600 -13610 {
lab=rB6}
N 550 -13630 600 -13630 {
lab=rB7}
N 550 -13650 600 -13650 {
lab=rB8}
N 550 -13670 600 -13670 {
lab=rB9}
N 550 -13690 600 -13690 {
lab=rB10}
N 550 -13710 600 -13710 {
lab=rB11}
N 550 -13730 600 -13730 {
lab=rB12}
N 550 -13750 600 -13750 {
lab=rB13}
N 550 -13770 600 -13770 {
lab=rB14}
N 550 -13790 600 -13790 {
lab=rB15}
N 670 -13780 670 -13500 {
lab=rB[0..15]
bus=true}
N 180 -13100 180 -12800 {bus=true
lab=cA[0..15]}
N 180 -12800 180 -12770 {bus=true
lab=cA[0..15]}
N 550 -12810 610 -12810 {
lab=cB0}
N 550 -12830 610 -12830 {
lab=cB1}
N 550 -12850 610 -12850 {
lab=cB2}
N 550 -12870 610 -12870 {
lab=cB3}
N 550 -12890 610 -12890 {
lab=cB4}
N 550 -12910 610 -12910 {
lab=cB5}
N 550 -12930 610 -12930 {
lab=cB6}
N 550 -12950 610 -12950 {
lab=cB7}
N 550 -12970 610 -12970 {
lab=cB8}
N 550 -12990 610 -12990 {
lab=cB9}
N 550 -13010 610 -13010 {
lab=cB10}
N 550 -13030 610 -13030 {
lab=cB11}
N 550 -13050 610 -13050 {
lab=cB12}
N 550 -13070 610 -13070 {
lab=cB13}
N 550 -13090 610 -13090 {
lab=cB14}
N 550 -13110 610 -13110 {
lab=cB15}
N 620 -13100 620 -12800 {bus=true
lab=cB[0..15]}
N 620 -12800 620 -12770 {bus=true
lab=cB[0..15]}
N 910 -13490 970 -13490 {
lab=rA0}
N 1320 -13490 1380 -13490 {
lab=rB0}
N 1320 -13510 1380 -13510 {
lab=rB1}
N 1320 -13530 1380 -13530 {
lab=rB2}
N 1320 -13550 1380 -13550 {
lab=rB3}
N 1320 -13570 1380 -13570 {
lab=rB4}
N 1320 -13590 1380 -13590 {
lab=rB5}
N 1320 -13610 1380 -13610 {
lab=rB6}
N 1320 -13630 1380 -13630 {
lab=rB7}
N 1320 -13650 1380 -13650 {
lab=rB8}
N 1320 -13670 1380 -13670 {
lab=rB9}
N 1320 -13690 1380 -13690 {
lab=rB10}
N 1320 -13710 1380 -13710 {
lab=rB11}
N 1320 -13730 1380 -13730 {
lab=rB12}
N 1320 -13750 1380 -13750 {
lab=rB13}
N 1320 -13770 1380 -13770 {
lab=rB14}
N 1320 -13790 1380 -13790 {
lab=rB15}
N 910 -14070 970 -14070 {
lab=col1_sel}
N 910 -14090 970 -14090 {
lab=row6_sel}
N 910 -13850 970 -13850 {
lab=Vcplus}
N 910 -13870 970 -13870 {
lab=Vcminus}
N 910 -13890 970 -13890 {
lab=Vref}
N 910 -13910 970 -13910 {
lab=Vref_comp}
N 910 -13930 970 -13930 {
lab=RISC_CLK}
N 1270 -14030 1330 -14030 {
lab=vssd1}
N 1270 -14050 1330 -14050 {
lab=vdda1}
N 1270 -14070 1330 -14070 {
lab=vccd1}
N 1270 -14090 1330 -14090 {
lab=latch_high1}
N 760 -13490 910 -13490 {
lab=rA0}
N 760 -13530 910 -13530 {
lab=rA2}
N 760 -13550 910 -13550 {
lab=rA3}
N 760 -13570 910 -13570 {
lab=rA4}
N 760 -13590 910 -13590 {
lab=rA5}
N 760 -13610 910 -13610 {
lab=rA6}
N 760 -13630 910 -13630 {
lab=rA7}
N 760 -13650 910 -13650 {
lab=rA8}
N 760 -13690 910 -13690 {
lab=rA10}
N 760 -13670 910 -13670 {
lab=rA9}
N 760 -13710 910 -13710 {
lab=rA11}
N 760 -13730 910 -13730 {
lab=rA12}
N 760 -13750 910 -13750 {
lab=rA13}
N 760 -13770 910 -13770 {
lab=rA14}
N 760 -13790 910 -13790 {
lab=rA15}
N 910 -13990 970 -13990 {
lab=SAMPLE}
N 910 -13970 970 -13970 {
lab=Vrminus}
N 910 -13950 970 -13950 {
lab=Vrplus}
N 760 -13510 910 -13510 {
lab=rA1}
N 910 -13510 970 -13510 {
lab=rA1}
N 910 -13530 970 -13530 {
lab=rA2}
N 910 -13550 970 -13550 {
lab=rA3}
N 910 -13570 970 -13570 {
lab=rA4}
N 910 -13590 970 -13590 {
lab=rA5}
N 910 -13610 970 -13610 {
lab=rA6}
N 910 -13630 970 -13630 {
lab=rA7}
N 910 -13650 970 -13650 {
lab=rA8}
N 910 -13670 970 -13670 {
lab=rA9}
N 910 -13690 970 -13690 {
lab=rA10}
N 910 -13710 970 -13710 {
lab=rA11}
N 910 -13730 970 -13730 {
lab=rA12}
N 910 -13750 970 -13750 {
lab=rA13}
N 910 -13770 970 -13770 {
lab=rA14}
N 910 -13790 970 -13790 {
lab=rA15}
N 750 -13780 750 -13440 {
lab=rA[0..15]
bus=true}
N 1270 -13490 1320 -13490 {
lab=rB0}
N 1270 -13510 1320 -13510 {
lab=rB1}
N 1390 -13500 1390 -13440 {
lab=rB[0..15]
bus=true}
N 1270 -13530 1320 -13530 {
lab=rB2}
N 1270 -13550 1320 -13550 {
lab=rB3}
N 1270 -13570 1320 -13570 {
lab=rB4}
N 1270 -13590 1320 -13590 {
lab=rB5}
N 1270 -13610 1320 -13610 {
lab=rB6}
N 1270 -13630 1320 -13630 {
lab=rB7}
N 1270 -13650 1320 -13650 {
lab=rB8}
N 1270 -13670 1320 -13670 {
lab=rB9}
N 1270 -13690 1320 -13690 {
lab=rB10}
N 1270 -13710 1320 -13710 {
lab=rB11}
N 1270 -13730 1320 -13730 {
lab=rB12}
N 1270 -13750 1320 -13750 {
lab=rB13}
N 1270 -13770 1320 -13770 {
lab=rB14}
N 1270 -13790 1320 -13790 {
lab=rB15}
N 1390 -13780 1390 -13500 {
lab=rB[0..15]
bus=true}
N 910 -14030 970 -14030 {
lab=WR}
N 910 -14050 970 -14050 {
lab=Vgnr}
N 910 -14010 970 -14010 {
lab=Vgpr}
N 1610 -14060 1670 -14060 {
lab=col2_sel}
N 1610 -14080 1670 -14080 {
lab=row6_sel}
N 1610 -13840 1670 -13840 {
lab=Vcplus}
N 1610 -13860 1670 -13860 {
lab=Vcminus}
N 1610 -13880 1670 -13880 {
lab=Vref}
N 1610 -13900 1670 -13900 {
lab=Vref_comp}
N 1610 -13920 1670 -13920 {
lab=RISC_CLK}
N 1610 -13980 1670 -13980 {
lab=SAMPLE}
N 1610 -13960 1670 -13960 {
lab=Vrminus}
N 1610 -13940 1670 -13940 {
lab=Vrplus}
N 1610 -14020 1670 -14020 {
lab=WR}
N 1610 -14040 1670 -14040 {
lab=Vgnr}
N 1610 -14000 1670 -14000 {
lab=Vgpr}
N 1970 -14020 2030 -14020 {
lab=vssd1}
N 1970 -14040 2030 -14040 {
lab=vdda1}
N 1970 -14060 2030 -14060 {
lab=vccd1}
N 1610 -13480 1670 -13480 {
lab=rA0}
N 2020 -13480 2080 -13480 {
lab=rB0}
N 2020 -13500 2080 -13500 {
lab=rB1}
N 2020 -13520 2080 -13520 {
lab=rB2}
N 2020 -13540 2080 -13540 {
lab=rB3}
N 2020 -13560 2080 -13560 {
lab=rB4}
N 2020 -13580 2080 -13580 {
lab=rB5}
N 2020 -13600 2080 -13600 {
lab=rB6}
N 2020 -13620 2080 -13620 {
lab=rB7}
N 2020 -13640 2080 -13640 {
lab=rB8}
N 2020 -13660 2080 -13660 {
lab=rB9}
N 2020 -13680 2080 -13680 {
lab=rB10}
N 2020 -13700 2080 -13700 {
lab=rB11}
N 2020 -13720 2080 -13720 {
lab=rB12}
N 2020 -13740 2080 -13740 {
lab=rB13}
N 2020 -13760 2080 -13760 {
lab=rB14}
N 2020 -13780 2080 -13780 {
lab=rB15}
N 1460 -13480 1610 -13480 {
lab=rA0}
N 1460 -13520 1610 -13520 {
lab=rA2}
N 1460 -13540 1610 -13540 {
lab=rA3}
N 1460 -13560 1610 -13560 {
lab=rA4}
N 1460 -13580 1610 -13580 {
lab=rA5}
N 1460 -13600 1610 -13600 {
lab=rA6}
N 1460 -13620 1610 -13620 {
lab=rA7}
N 1460 -13640 1610 -13640 {
lab=rA8}
N 1460 -13680 1610 -13680 {
lab=rA10}
N 1460 -13660 1610 -13660 {
lab=rA9}
N 1460 -13700 1610 -13700 {
lab=rA11}
N 1460 -13720 1610 -13720 {
lab=rA12}
N 1460 -13740 1610 -13740 {
lab=rA13}
N 1460 -13760 1610 -13760 {
lab=rA14}
N 1460 -13780 1610 -13780 {
lab=rA15}
N 1460 -13500 1610 -13500 {
lab=rA1}
N 1610 -13500 1670 -13500 {
lab=rA1}
N 1610 -13520 1670 -13520 {
lab=rA2}
N 1610 -13540 1670 -13540 {
lab=rA3}
N 1610 -13560 1670 -13560 {
lab=rA4}
N 1610 -13580 1670 -13580 {
lab=rA5}
N 1610 -13600 1670 -13600 {
lab=rA6}
N 1610 -13620 1670 -13620 {
lab=rA7}
N 1610 -13640 1670 -13640 {
lab=rA8}
N 1610 -13660 1670 -13660 {
lab=rA9}
N 1610 -13680 1670 -13680 {
lab=rA10}
N 1610 -13700 1670 -13700 {
lab=rA11}
N 1610 -13720 1670 -13720 {
lab=rA12}
N 1610 -13740 1670 -13740 {
lab=rA13}
N 1610 -13760 1670 -13760 {
lab=rA14}
N 1610 -13780 1670 -13780 {
lab=rA15}
N 1450 -13770 1450 -13430 {
lab=rA[0..15]
bus=true}
N 1970 -13480 2020 -13480 {
lab=rB0}
N 1970 -13500 2020 -13500 {
lab=rB1}
N 2090 -13490 2090 -13430 {
lab=rB[0..15]
bus=true}
N 1970 -13520 2020 -13520 {
lab=rB2}
N 1970 -13540 2020 -13540 {
lab=rB3}
N 1970 -13560 2020 -13560 {
lab=rB4}
N 1970 -13580 2020 -13580 {
lab=rB5}
N 1970 -13600 2020 -13600 {
lab=rB6}
N 1970 -13620 2020 -13620 {
lab=rB7}
N 1970 -13640 2020 -13640 {
lab=rB8}
N 1970 -13660 2020 -13660 {
lab=rB9}
N 1970 -13680 2020 -13680 {
lab=rB10}
N 1970 -13700 2020 -13700 {
lab=rB11}
N 1970 -13720 2020 -13720 {
lab=rB12}
N 1970 -13740 2020 -13740 {
lab=rB13}
N 1970 -13760 2020 -13760 {
lab=rB14}
N 1970 -13780 2020 -13780 {
lab=rB15}
N 2090 -13770 2090 -13490 {
lab=rB[0..15]
bus=true}
N 910 -12810 970 -12810 {
lab=cA0}
N 910 -12830 970 -12830 {
lab=cA1}
N 910 -12850 970 -12850 {
lab=cA2}
N 910 -12870 970 -12870 {
lab=cA3}
N 910 -12890 970 -12890 {
lab=cA4}
N 910 -12910 970 -12910 {
lab=cA5}
N 910 -12930 970 -12930 {
lab=cA6}
N 910 -12950 970 -12950 {
lab=cA7}
N 910 -12970 970 -12970 {
lab=cA8}
N 910 -12990 970 -12990 {
lab=cA9}
N 910 -13010 970 -13010 {
lab=cA10}
N 910 -13030 970 -13030 {
lab=cA11}
N 910 -13050 970 -13050 {
lab=cA12}
N 910 -13070 970 -13070 {
lab=cA13}
N 910 -13090 970 -13090 {
lab=cA14}
N 910 -13110 970 -13110 {
lab=cA15}
N 900 -13100 900 -12800 {bus=true
lab=cA[0..15]}
N 900 -12800 900 -12770 {bus=true
lab=cA[0..15]}
N 1270 -12810 1330 -12810 {
lab=cB0}
N 1270 -12830 1330 -12830 {
lab=cB1}
N 1270 -12850 1330 -12850 {
lab=cB2}
N 1270 -12870 1330 -12870 {
lab=cB3}
N 1270 -12890 1330 -12890 {
lab=cB4}
N 1270 -12910 1330 -12910 {
lab=cB5}
N 1270 -12930 1330 -12930 {
lab=cB6}
N 1270 -12950 1330 -12950 {
lab=cB7}
N 1270 -12970 1330 -12970 {
lab=cB8}
N 1270 -12990 1330 -12990 {
lab=cB9}
N 1270 -13010 1330 -13010 {
lab=cB10}
N 1270 -13030 1330 -13030 {
lab=cB11}
N 1270 -13050 1330 -13050 {
lab=cB12}
N 1270 -13070 1330 -13070 {
lab=cB13}
N 1270 -13090 1330 -13090 {
lab=cB14}
N 1270 -13110 1330 -13110 {
lab=cB15}
N 1340 -13100 1340 -12800 {bus=true
lab=cB[0..15]}
N 1340 -12800 1340 -12770 {bus=true
lab=cB[0..15]}
N 1610 -12800 1670 -12800 {
lab=cA0}
N 1610 -12820 1670 -12820 {
lab=cA1}
N 1610 -12840 1670 -12840 {
lab=cA2}
N 1610 -12860 1670 -12860 {
lab=cA3}
N 1610 -12880 1670 -12880 {
lab=cA4}
N 1610 -12900 1670 -12900 {
lab=cA5}
N 1610 -12920 1670 -12920 {
lab=cA6}
N 1610 -12940 1670 -12940 {
lab=cA7}
N 1610 -12960 1670 -12960 {
lab=cA8}
N 1610 -12980 1670 -12980 {
lab=cA9}
N 1610 -13000 1670 -13000 {
lab=cA10}
N 1610 -13020 1670 -13020 {
lab=cA11}
N 1610 -13040 1670 -13040 {
lab=cA12}
N 1610 -13060 1670 -13060 {
lab=cA13}
N 1610 -13080 1670 -13080 {
lab=cA14}
N 1610 -13100 1670 -13100 {
lab=cA15}
N 1600 -13090 1600 -12790 {bus=true
lab=cA[0..15]}
N 1600 -12790 1600 -12760 {bus=true
lab=cA[0..15]}
N 1970 -12800 2030 -12800 {
lab=cB0}
N 1970 -12820 2030 -12820 {
lab=cB1}
N 1970 -12840 2030 -12840 {
lab=cB2}
N 1970 -12860 2030 -12860 {
lab=cB3}
N 1970 -12880 2030 -12880 {
lab=cB4}
N 1970 -12900 2030 -12900 {
lab=cB5}
N 1970 -12920 2030 -12920 {
lab=cB6}
N 1970 -12940 2030 -12940 {
lab=cB7}
N 1970 -12960 2030 -12960 {
lab=cB8}
N 1970 -12980 2030 -12980 {
lab=cB9}
N 1970 -13000 2030 -13000 {
lab=cB10}
N 1970 -13020 2030 -13020 {
lab=cB11}
N 1970 -13040 2030 -13040 {
lab=cB12}
N 1970 -13060 2030 -13060 {
lab=cB13}
N 1970 -13080 2030 -13080 {
lab=cB14}
N 1970 -13100 2030 -13100 {
lab=cB15}
N 2040 -13090 2040 -12790 {bus=true
lab=cB[0..15]}
N 2040 -12790 2040 -12760 {bus=true
lab=cB[0..15]}
N 2340 -13490 2400 -13490 {
lab=rA0}
N 2750 -13490 2810 -13490 {
lab=rB0}
N 2750 -13510 2810 -13510 {
lab=rB1}
N 2750 -13530 2810 -13530 {
lab=rB2}
N 2750 -13550 2810 -13550 {
lab=rB3}
N 2750 -13570 2810 -13570 {
lab=rB4}
N 2750 -13590 2810 -13590 {
lab=rB5}
N 2750 -13610 2810 -13610 {
lab=rB6}
N 2750 -13630 2810 -13630 {
lab=rB7}
N 2750 -13650 2810 -13650 {
lab=rB8}
N 2750 -13670 2810 -13670 {
lab=rB9}
N 2750 -13690 2810 -13690 {
lab=rB10}
N 2750 -13710 2810 -13710 {
lab=rB11}
N 2750 -13730 2810 -13730 {
lab=rB12}
N 2750 -13750 2810 -13750 {
lab=rB13}
N 2750 -13770 2810 -13770 {
lab=rB14}
N 2750 -13790 2810 -13790 {
lab=rB15}
N 2190 -13490 2340 -13490 {
lab=rA0}
N 2190 -13530 2340 -13530 {
lab=rA2}
N 2190 -13550 2340 -13550 {
lab=rA3}
N 2190 -13570 2340 -13570 {
lab=rA4}
N 2190 -13590 2340 -13590 {
lab=rA5}
N 2190 -13610 2340 -13610 {
lab=rA6}
N 2190 -13630 2340 -13630 {
lab=rA7}
N 2190 -13650 2340 -13650 {
lab=rA8}
N 2190 -13690 2340 -13690 {
lab=rA10}
N 2190 -13670 2340 -13670 {
lab=rA9}
N 2190 -13710 2340 -13710 {
lab=rA11}
N 2190 -13730 2340 -13730 {
lab=rA12}
N 2190 -13750 2340 -13750 {
lab=rA13}
N 2190 -13770 2340 -13770 {
lab=rA14}
N 2190 -13790 2340 -13790 {
lab=rA15}
N 2190 -13510 2340 -13510 {
lab=rA1}
N 2340 -13510 2400 -13510 {
lab=rA1}
N 2340 -13530 2400 -13530 {
lab=rA2}
N 2340 -13550 2400 -13550 {
lab=rA3}
N 2340 -13570 2400 -13570 {
lab=rA4}
N 2340 -13590 2400 -13590 {
lab=rA5}
N 2340 -13610 2400 -13610 {
lab=rA6}
N 2340 -13630 2400 -13630 {
lab=rA7}
N 2340 -13650 2400 -13650 {
lab=rA8}
N 2340 -13670 2400 -13670 {
lab=rA9}
N 2340 -13690 2400 -13690 {
lab=rA10}
N 2340 -13710 2400 -13710 {
lab=rA11}
N 2340 -13730 2400 -13730 {
lab=rA12}
N 2340 -13750 2400 -13750 {
lab=rA13}
N 2340 -13770 2400 -13770 {
lab=rA14}
N 2340 -13790 2400 -13790 {
lab=rA15}
N 2180 -13780 2180 -13440 {
lab=rA[0..15]
bus=true}
N 2700 -13490 2750 -13490 {
lab=rB0}
N 2700 -13510 2750 -13510 {
lab=rB1}
N 2820 -13500 2820 -13440 {
lab=rB[0..15]
bus=true}
N 2700 -13530 2750 -13530 {
lab=rB2}
N 2700 -13550 2750 -13550 {
lab=rB3}
N 2700 -13570 2750 -13570 {
lab=rB4}
N 2700 -13590 2750 -13590 {
lab=rB5}
N 2700 -13610 2750 -13610 {
lab=rB6}
N 2700 -13630 2750 -13630 {
lab=rB7}
N 2700 -13650 2750 -13650 {
lab=rB8}
N 2700 -13670 2750 -13670 {
lab=rB9}
N 2700 -13690 2750 -13690 {
lab=rB10}
N 2700 -13710 2750 -13710 {
lab=rB11}
N 2700 -13730 2750 -13730 {
lab=rB12}
N 2700 -13750 2750 -13750 {
lab=rB13}
N 2700 -13770 2750 -13770 {
lab=rB14}
N 2700 -13790 2750 -13790 {
lab=rB15}
N 2820 -13780 2820 -13500 {
lab=rB[0..15]
bus=true}
N 2340 -12810 2400 -12810 {
lab=cA0}
N 2340 -12830 2400 -12830 {
lab=cA1}
N 2340 -12850 2400 -12850 {
lab=cA2}
N 2340 -12870 2400 -12870 {
lab=cA3}
N 2340 -12890 2400 -12890 {
lab=cA4}
N 2340 -12910 2400 -12910 {
lab=cA5}
N 2340 -12930 2400 -12930 {
lab=cA6}
N 2340 -12950 2400 -12950 {
lab=cA7}
N 2340 -12970 2400 -12970 {
lab=cA8}
N 2340 -12990 2400 -12990 {
lab=cA9}
N 2340 -13010 2400 -13010 {
lab=cA10}
N 2340 -13030 2400 -13030 {
lab=cA11}
N 2340 -13050 2400 -13050 {
lab=cA12}
N 2340 -13070 2400 -13070 {
lab=cA13}
N 2340 -13090 2400 -13090 {
lab=cA14}
N 2340 -13110 2400 -13110 {
lab=cA15}
N 2330 -13100 2330 -12800 {bus=true
lab=cA[0..15]}
N 2330 -12800 2330 -12770 {bus=true
lab=cA[0..15]}
N 2700 -12810 2760 -12810 {
lab=cB0}
N 2700 -12830 2760 -12830 {
lab=cB1}
N 2700 -12850 2760 -12850 {
lab=cB2}
N 2700 -12870 2760 -12870 {
lab=cB3}
N 2700 -12890 2760 -12890 {
lab=cB4}
N 2700 -12910 2760 -12910 {
lab=cB5}
N 2700 -12930 2760 -12930 {
lab=cB6}
N 2700 -12950 2760 -12950 {
lab=cB7}
N 2700 -12970 2760 -12970 {
lab=cB8}
N 2700 -12990 2760 -12990 {
lab=cB9}
N 2700 -13010 2760 -13010 {
lab=cB10}
N 2700 -13030 2760 -13030 {
lab=cB11}
N 2700 -13050 2760 -13050 {
lab=cB12}
N 2700 -13070 2760 -13070 {
lab=cB13}
N 2700 -13090 2760 -13090 {
lab=cB14}
N 2700 -13110 2760 -13110 {
lab=cB15}
N 2770 -13100 2770 -12800 {bus=true
lab=cB[0..15]}
N 2770 -12800 2770 -12770 {bus=true
lab=cB[0..15]}
N 3040 -13480 3100 -13480 {
lab=rA0}
N 3450 -13480 3510 -13480 {
lab=rB0}
N 3450 -13500 3510 -13500 {
lab=rB1}
N 3450 -13520 3510 -13520 {
lab=rB2}
N 3450 -13540 3510 -13540 {
lab=rB3}
N 3450 -13560 3510 -13560 {
lab=rB4}
N 3450 -13580 3510 -13580 {
lab=rB5}
N 3450 -13600 3510 -13600 {
lab=rB6}
N 3450 -13620 3510 -13620 {
lab=rB7}
N 3450 -13640 3510 -13640 {
lab=rB8}
N 3450 -13660 3510 -13660 {
lab=rB9}
N 3450 -13680 3510 -13680 {
lab=rB10}
N 3450 -13700 3510 -13700 {
lab=rB11}
N 3450 -13720 3510 -13720 {
lab=rB12}
N 3450 -13740 3510 -13740 {
lab=rB13}
N 3450 -13760 3510 -13760 {
lab=rB14}
N 3450 -13780 3510 -13780 {
lab=rB15}
N 2890 -13480 3040 -13480 {
lab=rA0}
N 2890 -13520 3040 -13520 {
lab=rA2}
N 2890 -13540 3040 -13540 {
lab=rA3}
N 2890 -13560 3040 -13560 {
lab=rA4}
N 2890 -13580 3040 -13580 {
lab=rA5}
N 2890 -13600 3040 -13600 {
lab=rA6}
N 2890 -13620 3040 -13620 {
lab=rA7}
N 2890 -13640 3040 -13640 {
lab=rA8}
N 2890 -13680 3040 -13680 {
lab=rA10}
N 2890 -13660 3040 -13660 {
lab=rA9}
N 2890 -13700 3040 -13700 {
lab=rA11}
N 2890 -13720 3040 -13720 {
lab=rA12}
N 2890 -13740 3040 -13740 {
lab=rA13}
N 2890 -13760 3040 -13760 {
lab=rA14}
N 2890 -13780 3040 -13780 {
lab=rA15}
N 2890 -13500 3040 -13500 {
lab=rA1}
N 3040 -13500 3100 -13500 {
lab=rA1}
N 3040 -13520 3100 -13520 {
lab=rA2}
N 3040 -13540 3100 -13540 {
lab=rA3}
N 3040 -13560 3100 -13560 {
lab=rA4}
N 3040 -13580 3100 -13580 {
lab=rA5}
N 3040 -13600 3100 -13600 {
lab=rA6}
N 3040 -13620 3100 -13620 {
lab=rA7}
N 3040 -13640 3100 -13640 {
lab=rA8}
N 3040 -13660 3100 -13660 {
lab=rA9}
N 3040 -13680 3100 -13680 {
lab=rA10}
N 3040 -13700 3100 -13700 {
lab=rA11}
N 3040 -13720 3100 -13720 {
lab=rA12}
N 3040 -13740 3100 -13740 {
lab=rA13}
N 3040 -13760 3100 -13760 {
lab=rA14}
N 3040 -13780 3100 -13780 {
lab=rA15}
N 2880 -13770 2880 -13430 {
lab=rA[0..15]
bus=true}
N 3400 -13480 3450 -13480 {
lab=rB0}
N 3400 -13500 3450 -13500 {
lab=rB1}
N 3520 -13490 3520 -13430 {
lab=rB[0..15]
bus=true}
N 3400 -13520 3450 -13520 {
lab=rB2}
N 3400 -13540 3450 -13540 {
lab=rB3}
N 3400 -13560 3450 -13560 {
lab=rB4}
N 3400 -13580 3450 -13580 {
lab=rB5}
N 3400 -13600 3450 -13600 {
lab=rB6}
N 3400 -13620 3450 -13620 {
lab=rB7}
N 3400 -13640 3450 -13640 {
lab=rB8}
N 3400 -13660 3450 -13660 {
lab=rB9}
N 3400 -13680 3450 -13680 {
lab=rB10}
N 3400 -13700 3450 -13700 {
lab=rB11}
N 3400 -13720 3450 -13720 {
lab=rB12}
N 3400 -13740 3450 -13740 {
lab=rB13}
N 3400 -13760 3450 -13760 {
lab=rB14}
N 3400 -13780 3450 -13780 {
lab=rB15}
N 3520 -13770 3520 -13490 {
lab=rB[0..15]
bus=true}
N 3040 -12800 3100 -12800 {
lab=cA0}
N 3040 -12820 3100 -12820 {
lab=cA1}
N 3040 -12840 3100 -12840 {
lab=cA2}
N 3040 -12860 3100 -12860 {
lab=cA3}
N 3040 -12880 3100 -12880 {
lab=cA4}
N 3040 -12900 3100 -12900 {
lab=cA5}
N 3040 -12920 3100 -12920 {
lab=cA6}
N 3040 -12940 3100 -12940 {
lab=cA7}
N 3040 -12960 3100 -12960 {
lab=cA8}
N 3040 -12980 3100 -12980 {
lab=cA9}
N 3040 -13000 3100 -13000 {
lab=cA10}
N 3040 -13020 3100 -13020 {
lab=cA11}
N 3040 -13040 3100 -13040 {
lab=cA12}
N 3040 -13060 3100 -13060 {
lab=cA13}
N 3040 -13080 3100 -13080 {
lab=cA14}
N 3040 -13100 3100 -13100 {
lab=cA15}
N 3030 -13090 3030 -12790 {bus=true
lab=cA[0..15]}
N 3030 -12790 3030 -12760 {bus=true
lab=cA[0..15]}
N 3400 -12800 3460 -12800 {
lab=cB0}
N 3400 -12820 3460 -12820 {
lab=cB1}
N 3400 -12840 3460 -12840 {
lab=cB2}
N 3400 -12860 3460 -12860 {
lab=cB3}
N 3400 -12880 3460 -12880 {
lab=cB4}
N 3400 -12900 3460 -12900 {
lab=cB5}
N 3400 -12920 3460 -12920 {
lab=cB6}
N 3400 -12940 3460 -12940 {
lab=cB7}
N 3400 -12960 3460 -12960 {
lab=cB8}
N 3400 -12980 3460 -12980 {
lab=cB9}
N 3400 -13000 3460 -13000 {
lab=cB10}
N 3400 -13020 3460 -13020 {
lab=cB11}
N 3400 -13040 3460 -13040 {
lab=cB12}
N 3400 -13060 3460 -13060 {
lab=cB13}
N 3400 -13080 3460 -13080 {
lab=cB14}
N 3400 -13100 3460 -13100 {
lab=cB15}
N 3470 -13090 3470 -12790 {bus=true
lab=cB[0..15]}
N 3470 -12790 3470 -12760 {bus=true
lab=cB[0..15]}
N 3750 -13480 3810 -13480 {
lab=rA0}
N 4160 -13480 4220 -13480 {
lab=rB0}
N 4160 -13500 4220 -13500 {
lab=rB1}
N 4160 -13520 4220 -13520 {
lab=rB2}
N 4160 -13540 4220 -13540 {
lab=rB3}
N 4160 -13560 4220 -13560 {
lab=rB4}
N 4160 -13580 4220 -13580 {
lab=rB5}
N 4160 -13600 4220 -13600 {
lab=rB6}
N 4160 -13620 4220 -13620 {
lab=rB7}
N 4160 -13640 4220 -13640 {
lab=rB8}
N 4160 -13660 4220 -13660 {
lab=rB9}
N 4160 -13680 4220 -13680 {
lab=rB10}
N 4160 -13700 4220 -13700 {
lab=rB11}
N 4160 -13720 4220 -13720 {
lab=rB12}
N 4160 -13740 4220 -13740 {
lab=rB13}
N 4160 -13760 4220 -13760 {
lab=rB14}
N 4160 -13780 4220 -13780 {
lab=rB15}
N 3600 -13480 3750 -13480 {
lab=rA0}
N 3600 -13520 3750 -13520 {
lab=rA2}
N 3600 -13540 3750 -13540 {
lab=rA3}
N 3600 -13560 3750 -13560 {
lab=rA4}
N 3600 -13580 3750 -13580 {
lab=rA5}
N 3600 -13600 3750 -13600 {
lab=rA6}
N 3600 -13620 3750 -13620 {
lab=rA7}
N 3600 -13640 3750 -13640 {
lab=rA8}
N 3600 -13680 3750 -13680 {
lab=rA10}
N 3600 -13660 3750 -13660 {
lab=rA9}
N 3600 -13700 3750 -13700 {
lab=rA11}
N 3600 -13720 3750 -13720 {
lab=rA12}
N 3600 -13740 3750 -13740 {
lab=rA13}
N 3600 -13760 3750 -13760 {
lab=rA14}
N 3600 -13780 3750 -13780 {
lab=rA15}
N 3600 -13500 3750 -13500 {
lab=rA1}
N 3750 -13500 3810 -13500 {
lab=rA1}
N 3750 -13520 3810 -13520 {
lab=rA2}
N 3750 -13540 3810 -13540 {
lab=rA3}
N 3750 -13560 3810 -13560 {
lab=rA4}
N 3750 -13580 3810 -13580 {
lab=rA5}
N 3750 -13600 3810 -13600 {
lab=rA6}
N 3750 -13620 3810 -13620 {
lab=rA7}
N 3750 -13640 3810 -13640 {
lab=rA8}
N 3750 -13660 3810 -13660 {
lab=rA9}
N 3750 -13680 3810 -13680 {
lab=rA10}
N 3750 -13700 3810 -13700 {
lab=rA11}
N 3750 -13720 3810 -13720 {
lab=rA12}
N 3750 -13740 3810 -13740 {
lab=rA13}
N 3750 -13760 3810 -13760 {
lab=rA14}
N 3750 -13780 3810 -13780 {
lab=rA15}
N 3590 -13770 3590 -13430 {
lab=rA[0..15]
bus=true}
N 4110 -13480 4160 -13480 {
lab=rB0}
N 4110 -13500 4160 -13500 {
lab=rB1}
N 4230 -13490 4230 -13430 {
lab=rB[0..15]
bus=true}
N 4110 -13520 4160 -13520 {
lab=rB2}
N 4110 -13540 4160 -13540 {
lab=rB3}
N 4110 -13560 4160 -13560 {
lab=rB4}
N 4110 -13580 4160 -13580 {
lab=rB5}
N 4110 -13600 4160 -13600 {
lab=rB6}
N 4110 -13620 4160 -13620 {
lab=rB7}
N 4110 -13640 4160 -13640 {
lab=rB8}
N 4110 -13660 4160 -13660 {
lab=rB9}
N 4110 -13680 4160 -13680 {
lab=rB10}
N 4110 -13700 4160 -13700 {
lab=rB11}
N 4110 -13720 4160 -13720 {
lab=rB12}
N 4110 -13740 4160 -13740 {
lab=rB13}
N 4110 -13760 4160 -13760 {
lab=rB14}
N 4110 -13780 4160 -13780 {
lab=rB15}
N 4230 -13770 4230 -13490 {
lab=rB[0..15]
bus=true}
N 3750 -12800 3810 -12800 {
lab=cA0}
N 3750 -12820 3810 -12820 {
lab=cA1}
N 3750 -12840 3810 -12840 {
lab=cA2}
N 3750 -12860 3810 -12860 {
lab=cA3}
N 3750 -12880 3810 -12880 {
lab=cA4}
N 3750 -12900 3810 -12900 {
lab=cA5}
N 3750 -12920 3810 -12920 {
lab=cA6}
N 3750 -12940 3810 -12940 {
lab=cA7}
N 3750 -12960 3810 -12960 {
lab=cA8}
N 3750 -12980 3810 -12980 {
lab=cA9}
N 3750 -13000 3810 -13000 {
lab=cA10}
N 3750 -13020 3810 -13020 {
lab=cA11}
N 3750 -13040 3810 -13040 {
lab=cA12}
N 3750 -13060 3810 -13060 {
lab=cA13}
N 3750 -13080 3810 -13080 {
lab=cA14}
N 3750 -13100 3810 -13100 {
lab=cA15}
N 3740 -13090 3740 -12790 {bus=true
lab=cA[0..15]}
N 3740 -12790 3740 -12760 {bus=true
lab=cA[0..15]}
N 4110 -12800 4170 -12800 {
lab=cB0}
N 4110 -12820 4170 -12820 {
lab=cB1}
N 4110 -12840 4170 -12840 {
lab=cB2}
N 4110 -12860 4170 -12860 {
lab=cB3}
N 4110 -12880 4170 -12880 {
lab=cB4}
N 4110 -12900 4170 -12900 {
lab=cB5}
N 4110 -12920 4170 -12920 {
lab=cB6}
N 4110 -12940 4170 -12940 {
lab=cB7}
N 4110 -12960 4170 -12960 {
lab=cB8}
N 4110 -12980 4170 -12980 {
lab=cB9}
N 4110 -13000 4170 -13000 {
lab=cB10}
N 4110 -13020 4170 -13020 {
lab=cB11}
N 4110 -13040 4170 -13040 {
lab=cB12}
N 4110 -13060 4170 -13060 {
lab=cB13}
N 4110 -13080 4170 -13080 {
lab=cB14}
N 4110 -13100 4170 -13100 {
lab=cB15}
N 4180 -13090 4180 -12790 {bus=true
lab=cB[0..15]}
N 4180 -12790 4180 -12760 {bus=true
lab=cB[0..15]}
N 2340 -14070 2400 -14070 {
lab=col3_sel}
N 2340 -14090 2400 -14090 {
lab=row6_sel}
N 2340 -13850 2400 -13850 {
lab=Vcplus}
N 2340 -13870 2400 -13870 {
lab=Vcminus}
N 2340 -13890 2400 -13890 {
lab=Vref}
N 2340 -13910 2400 -13910 {
lab=Vref_comp}
N 2340 -13930 2400 -13930 {
lab=RISC_CLK}
N 2340 -13990 2400 -13990 {
lab=SAMPLE}
N 2340 -13970 2400 -13970 {
lab=Vrminus}
N 2340 -13950 2400 -13950 {
lab=Vrplus}
N 2340 -14030 2400 -14030 {
lab=WR}
N 2340 -14050 2400 -14050 {
lab=Vgnr}
N 2340 -14010 2400 -14010 {
lab=Vgpr}
N 3040 -14060 3100 -14060 {
lab=col4_sel}
N 3040 -14080 3100 -14080 {
lab=row6_sel}
N 3040 -13840 3100 -13840 {
lab=Vcplus}
N 3040 -13860 3100 -13860 {
lab=Vcminus}
N 3040 -13880 3100 -13880 {
lab=Vref}
N 3040 -13900 3100 -13900 {
lab=Vref_comp}
N 3040 -13920 3100 -13920 {
lab=RISC_CLK}
N 3040 -13980 3100 -13980 {
lab=SAMPLE}
N 3040 -13960 3100 -13960 {
lab=Vrminus}
N 3040 -13940 3100 -13940 {
lab=Vrplus}
N 3040 -14020 3100 -14020 {
lab=WR}
N 3040 -14040 3100 -14040 {
lab=Vgnr}
N 3040 -14000 3100 -14000 {
lab=Vgpr}
N 3750 -14060 3810 -14060 {
lab=col5_sel}
N 3750 -14080 3810 -14080 {
lab=row6_sel}
N 3750 -13840 3810 -13840 {
lab=Vcplus}
N 3750 -13860 3810 -13860 {
lab=Vcminus}
N 3750 -13880 3810 -13880 {
lab=Vref}
N 3750 -13900 3810 -13900 {
lab=Vref_comp}
N 3750 -13920 3810 -13920 {
lab=RISC_CLK}
N 3750 -13980 3810 -13980 {
lab=SAMPLE}
N 3750 -13960 3810 -13960 {
lab=Vrminus}
N 3750 -13940 3810 -13940 {
lab=Vrplus}
N 3750 -14020 3810 -14020 {
lab=WR}
N 3750 -14040 3810 -14040 {
lab=Vgnr}
N 3750 -14000 3810 -14000 {
lab=Vgpr}
C {core.sym} 400 -1050 0 0 {name=x1}
C {core.sym} 1120 -1050 0 0 {name=x2}
C {devices/ipin.sym} -880 -960 2 1 {name=p4 sig_type=std_logic lab=WL[0..15]}
C {devices/lab_pin.sym} 190 -1810 0 0 {name=l3988 lab=row0_sel}
C {devices/lab_pin.sym} 190 -1790 0 0 {name=l3962 lab=col0_sel}
C {devices/ipin.sym} 190 -1670 2 1 {name=p11 lab=Vrplus}
C {devices/ipin.sym} 190 -1690 2 1 {name=p17 lab=Vrminus}
C {devices/ipin.sym} 190 -1730 0 0 {name=p21 lab=Vgpr}
C {devices/ipin.sym} 190 -1770 0 0 {name=p8 lab=Vgnr}
C {devices/ipin.sym} 190 -1750 0 0 {name=p49 lab=WR}
C {devices/ipin.sym} 190 -1710 0 0 {name=p50 lab=SAMPLE}
C {devices/iopin.sym} -880 -1200 2 0 {name=p1 lab=vdda1}
C {devices/iopin.sym} -880 -1180 0 1 {name=p2 lab=vssa1}
C {devices/ipin.sym} 190 -1610 0 0 {name=p5 lab=Vref}
C {devices/ipin.sym} 190 -1570 0 0 {name=p6 lab=Vcplus}
C {devices/ipin.sym} 190 -1590 0 0 {name=p7 lab=Vcminus}
C {devices/iopin.sym} -880 -1220 2 0 {name=p3 lab=vccd1}
C {devices/ipin.sym} 190 -1630 2 1 {name=p19 sig_type=std_logic lab=Vref_comp}
C {devices/ipin.sym} 190 -1650 2 1 {name=p18 sig_type=std_logic lab=RISC_CLK}
C {devices/opin.sym} 610 -1810 2 1 {name=p51 lab=latch_high0}
C {devices/code.sym} -520 -1950 0 0 {name=TT_MODELS 
only_toplevel=true 
format="tcleval( @value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false}
C {core.sym} 1820 -1040 0 0 {name=x3}
C {devices/opin.sym} 2030 -1800 2 1 {name=p52 lab=latch_high2}
C {devices/lab_pin.sym} 910 -1690 2 1 {name=l71 lab=Vrminus}
C {devices/lab_pin.sym} 910 -1710 0 0 {name=l74 lab=SAMPLE}
C {core.sym} 2550 -1050 0 0 {name=x4}
C {devices/lab_pin.sym} 2760 -1770 2 0 {name=l153 lab=vdda1}
C {devices/lab_pin.sym} 2760 -1790 2 0 {name=l193 lab=vccd1}
C {devices/opin.sym} 2760 -1810 2 1 {name=p54 lab=latch_high3}
C {core.sym} 3250 -1040 0 0 {name=x5}
C {devices/lab_pin.sym} 3460 -1760 2 0 {name=l286 lab=vdda1}
C {devices/lab_pin.sym} 3460 -1780 2 0 {name=l288 lab=vccd1}
C {devices/opin.sym} 3460 -1800 2 1 {name=p56 lab=latch_high4}
C {core.sym} 3960 -1040 0 0 {name=x6}
C {devices/lab_pin.sym} 4170 -1760 2 0 {name=l381 lab=vdda1}
C {devices/lab_pin.sym} 4170 -1780 2 0 {name=l383 lab=vccd1}
C {devices/opin.sym} 4170 -1800 2 1 {name=p58 lab=latch_high5}
C {core.sym} 1120 -3180 0 0 {name=x7}
C {core.sym} 1820 -3170 0 0 {name=x8}
C {core.sym} 2550 -3180 0 0 {name=x9}
C {core.sym} 3250 -3170 0 0 {name=x10}
C {core.sym} 3960 -3170 0 0 {name=x11}
C {core.sym} 400 -3180 0 0 {name=x12}
C {core.sym} 1120 -5180 0 0 {name=x13}
C {core.sym} 1820 -5170 0 0 {name=x14}
C {core.sym} 2550 -5180 0 0 {name=x15}
C {core.sym} 3250 -5170 0 0 {name=x16}
C {core.sym} 3960 -5170 0 0 {name=x17}
C {core.sym} 400 -5180 0 0 {name=x18}
C {core.sym} 1120 -7200 0 0 {name=x19}
C {core.sym} 1820 -7190 0 0 {name=x20}
C {core.sym} 2550 -7200 0 0 {name=x21}
C {core.sym} 3250 -7190 0 0 {name=x22}
C {core.sym} 3960 -7190 0 0 {name=x23}
C {core.sym} 400 -7200 0 0 {name=x24}
C {core.sym} 1120 -9190 0 0 {name=x25}
C {core.sym} 1820 -9180 0 0 {name=x26}
C {core.sym} 2550 -9190 0 0 {name=x27}
C {core.sym} 3250 -9180 0 0 {name=x28}
C {core.sym} 3960 -9180 0 0 {name=x29}
C {core.sym} 400 -9190 0 0 {name=x30}
C {core.sym} 1120 -11260 0 0 {name=x31}
C {core.sym} 1820 -11250 0 0 {name=x32}
C {core.sym} 2550 -11260 0 0 {name=x33}
C {core.sym} 3250 -11250 0 0 {name=x34}
C {core.sym} 3960 -11250 0 0 {name=x35}
C {core.sym} 400 -11260 0 0 {name=x36}
C {core.sym} 1120 -13330 0 0 {name=x37}
C {core.sym} 1820 -13320 0 0 {name=x38}
C {core.sym} 2550 -13330 0 0 {name=x39}
C {core.sym} 3250 -13320 0 0 {name=x40}
C {core.sym} 3960 -13320 0 0 {name=x41}
C {core.sym} 400 -13330 0 0 {name=x42}
C {decoder_3to8_top.sym} -550 -1630 0 0 {name=x43}
C {devices/lab_pin.sym} -340 -1700 0 1 {name=l3963 lab=col0_sel}
C {devices/lab_pin.sym} -340 -1680 0 1 {name=l3965 lab=col1_sel}
C {devices/lab_pin.sym} -340 -1660 0 1 {name=l3966 lab=col2_sel}
C {devices/lab_pin.sym} -340 -1640 0 1 {name=l3967 lab=col3_sel}
C {devices/lab_pin.sym} -340 -1620 0 1 {name=l3968 lab=col4_sel}
C {devices/lab_pin.sym} -340 -1600 0 1 {name=l3969 lab=col5_sel}
C {devices/lab_pin.sym} -760 -1680 0 0 {name=l3972 lab=vssa1}
C {devices/lab_pin.sym} -760 -1700 2 1 {name=l3973 lab=vccd1}
C {devices/ipin.sym} -760 -1600 0 0 {name=p3977 lab=EN}
C {devices/noconn.sym} -340 -1560 0 1 {name=l3970}
C {devices/noconn.sym} -340 -1580 0 1 {name=l3971}
C {decoder_3to8_top.sym} -550 -1350 0 0 {name=x44}
C {devices/lab_pin.sym} -340 -1420 0 1 {name=l3978 lab=row0_sel}
C {devices/lab_pin.sym} -340 -1400 0 1 {name=l3979 lab=row1_sel}
C {devices/lab_pin.sym} -340 -1380 0 1 {name=l3980 lab=row2_sel}
C {devices/lab_pin.sym} -340 -1360 0 1 {name=l3981 lab=row3_sel}
C {devices/lab_pin.sym} -340 -1340 0 1 {name=l3982 lab=row4_sel}
C {devices/lab_pin.sym} -340 -1320 0 1 {name=l3983 lab=row5_sel}
C {devices/lab_pin.sym} -760 -1400 0 0 {name=l3984 lab=vssa1}
C {devices/lab_pin.sym} -760 -1420 2 1 {name=l3985 lab=vccd1}
C {devices/noconn.sym} -340 -1280 0 1 {name=l3986}
C {devices/lab_pin.sym} -340 -1300 0 1 {name=l3987 lab=row6_sel}
C {devices/lab_wire.sym} 130 -1170 0 0 {name=l3995 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -1150 0 0 {name=l3996 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -1130 0 0 {name=l3997 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -1110 0 0 {name=l3998 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -1090 0 0 {name=l3999 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -1070 0 0 {name=l4000 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -1050 0 0 {name=l4001 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -1030 0 0 {name=l4002 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -1010 0 0 {name=l4003 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -990 0 0 {name=l4004 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -970 0 0 {name=l4005 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -950 0 0 {name=l4006 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -930 0 0 {name=l4007 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -910 0 0 {name=l4008 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -890 0 0 {name=l4009 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -870 0 0 {name=l4010 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -830 3 0 {name=l4011 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -870 2 0 {name=r1}
C {devices/bus_connect_nolab.sym} 70 -890 2 0 {name=r2}
C {devices/bus_connect_nolab.sym} 70 -910 2 0 {name=r3}
C {devices/bus_connect_nolab.sym} 70 -930 2 0 {name=r4}
C {devices/bus_connect_nolab.sym} 70 -950 2 0 {name=r5}
C {devices/bus_connect_nolab.sym} 70 -970 2 0 {name=r6}
C {devices/bus_connect_nolab.sym} 70 -990 2 0 {name=r7}
C {devices/bus_connect_nolab.sym} 70 -1010 2 0 {name=r8}
C {devices/bus_connect_nolab.sym} 70 -1030 2 0 {name=r9}
C {devices/bus_connect_nolab.sym} 70 -1050 2 0 {name=r10}
C {devices/bus_connect_nolab.sym} 70 -1070 2 0 {name=r11}
C {devices/bus_connect_nolab.sym} 70 -1090 2 0 {name=r12}
C {devices/bus_connect_nolab.sym} 70 -1110 2 0 {name=r13}
C {devices/bus_connect_nolab.sym} 70 -1130 2 0 {name=r14}
C {devices/bus_connect_nolab.sym} 70 -1150 2 0 {name=r15}
C {devices/bus_connect_nolab.sym} 70 -1170 2 0 {name=r16}
C {devices/lab_wire.sym} 850 -1170 0 0 {name=l4012 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -1150 0 0 {name=l4013 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -1130 0 0 {name=l4014 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -1110 0 0 {name=l4015 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -1090 0 0 {name=l4016 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -1070 0 0 {name=l4017 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -1050 0 0 {name=l4018 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -1030 0 0 {name=l4019 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -1010 0 0 {name=l4020 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -990 0 0 {name=l4021 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -970 0 0 {name=l4022 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -950 0 0 {name=l4023 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -930 0 0 {name=l4024 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -910 0 0 {name=l4025 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -890 0 0 {name=l4026 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -830 3 0 {name=l4027 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -870 2 0 {name=r17}
C {devices/bus_connect_nolab.sym} 790 -890 2 0 {name=r18}
C {devices/bus_connect_nolab.sym} 790 -910 2 0 {name=r19}
C {devices/bus_connect_nolab.sym} 790 -930 2 0 {name=r20}
C {devices/bus_connect_nolab.sym} 790 -950 2 0 {name=r21}
C {devices/bus_connect_nolab.sym} 790 -970 2 0 {name=r22}
C {devices/bus_connect_nolab.sym} 790 -990 2 0 {name=r23}
C {devices/bus_connect_nolab.sym} 790 -1010 2 0 {name=r24}
C {devices/bus_connect_nolab.sym} 790 -1030 2 0 {name=r25}
C {devices/bus_connect_nolab.sym} 790 -1050 2 0 {name=r26}
C {devices/bus_connect_nolab.sym} 790 -1070 2 0 {name=r27}
C {devices/bus_connect_nolab.sym} 790 -1090 2 0 {name=r28}
C {devices/bus_connect_nolab.sym} 790 -1110 2 0 {name=r29}
C {devices/bus_connect_nolab.sym} 790 -1130 2 0 {name=r30}
C {devices/bus_connect_nolab.sym} 790 -1150 2 0 {name=r31}
C {devices/bus_connect_nolab.sym} 790 -1170 2 0 {name=r32}
C {devices/lab_wire.sym} 850 -870 0 0 {name=l1 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -1160 0 0 {name=l2 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -1140 0 0 {name=l3 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -1120 0 0 {name=l8 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -1100 0 0 {name=l9 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -1080 0 0 {name=l10 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -1060 0 0 {name=l11 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -1040 0 0 {name=l12 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -1020 0 0 {name=l13 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -1000 0 0 {name=l14 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -980 0 0 {name=l15 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -960 0 0 {name=l16 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -940 0 0 {name=l17 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -920 0 0 {name=l18 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -900 0 0 {name=l19 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -880 0 0 {name=l20 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -820 0 0 {name=l21 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -860 2 0 {name=r33}
C {devices/bus_connect_nolab.sym} 1490 -880 2 0 {name=r34}
C {devices/bus_connect_nolab.sym} 1490 -900 2 0 {name=r35}
C {devices/bus_connect_nolab.sym} 1490 -920 2 0 {name=r36}
C {devices/bus_connect_nolab.sym} 1490 -940 2 0 {name=r37}
C {devices/bus_connect_nolab.sym} 1490 -960 2 0 {name=r38}
C {devices/bus_connect_nolab.sym} 1490 -980 2 0 {name=r39}
C {devices/bus_connect_nolab.sym} 1490 -1000 2 0 {name=r40}
C {devices/bus_connect_nolab.sym} 1490 -1020 2 0 {name=r41}
C {devices/bus_connect_nolab.sym} 1490 -1040 2 0 {name=r42}
C {devices/bus_connect_nolab.sym} 1490 -1060 2 0 {name=r43}
C {devices/bus_connect_nolab.sym} 1490 -1080 2 0 {name=r44}
C {devices/bus_connect_nolab.sym} 1490 -1100 2 0 {name=r45}
C {devices/bus_connect_nolab.sym} 1490 -1120 2 0 {name=r46}
C {devices/bus_connect_nolab.sym} 1490 -1140 2 0 {name=r47}
C {devices/bus_connect_nolab.sym} 1490 -1160 2 0 {name=r48}
C {devices/lab_wire.sym} 1550 -860 0 0 {name=l22 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -1170 0 0 {name=l23 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -1150 0 0 {name=l55 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -1130 0 0 {name=l56 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -1110 0 0 {name=l57 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -1090 0 0 {name=l58 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -1070 0 0 {name=l60 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -1050 0 0 {name=l61 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -1030 0 0 {name=l62 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -1010 0 0 {name=l63 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -990 0 0 {name=l64 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -970 0 0 {name=l65 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -950 0 0 {name=l78 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -930 0 0 {name=l112 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -910 0 0 {name=l113 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -890 0 0 {name=l194 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -830 0 0 {name=l195 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -870 2 0 {name=r49}
C {devices/bus_connect_nolab.sym} 2220 -890 2 0 {name=r50}
C {devices/bus_connect_nolab.sym} 2220 -910 2 0 {name=r51}
C {devices/bus_connect_nolab.sym} 2220 -930 2 0 {name=r52}
C {devices/bus_connect_nolab.sym} 2220 -950 2 0 {name=r53}
C {devices/bus_connect_nolab.sym} 2220 -970 2 0 {name=r54}
C {devices/bus_connect_nolab.sym} 2220 -990 2 0 {name=r55}
C {devices/bus_connect_nolab.sym} 2220 -1010 2 0 {name=r56}
C {devices/bus_connect_nolab.sym} 2220 -1030 2 0 {name=r57}
C {devices/bus_connect_nolab.sym} 2220 -1050 2 0 {name=r58}
C {devices/bus_connect_nolab.sym} 2220 -1070 2 0 {name=r59}
C {devices/bus_connect_nolab.sym} 2220 -1090 2 0 {name=r60}
C {devices/bus_connect_nolab.sym} 2220 -1110 2 0 {name=r61}
C {devices/bus_connect_nolab.sym} 2220 -1130 2 0 {name=r62}
C {devices/bus_connect_nolab.sym} 2220 -1150 2 0 {name=r63}
C {devices/bus_connect_nolab.sym} 2220 -1170 2 0 {name=r64}
C {devices/lab_wire.sym} 2280 -870 0 0 {name=l196 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -1160 0 0 {name=l197 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -1140 0 0 {name=l198 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -1120 0 0 {name=l199 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -1100 0 0 {name=l200 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -1080 0 0 {name=l201 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -1060 0 0 {name=l202 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -1040 0 0 {name=l203 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -1020 0 0 {name=l204 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -1000 0 0 {name=l205 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -980 0 0 {name=l206 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -960 0 0 {name=l207 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -940 0 0 {name=l208 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -920 0 0 {name=l209 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -900 0 0 {name=l289 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -880 0 0 {name=l290 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -820 0 0 {name=l291 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -860 2 0 {name=r65}
C {devices/bus_connect_nolab.sym} 2920 -880 2 0 {name=r66}
C {devices/bus_connect_nolab.sym} 2920 -900 2 0 {name=r67}
C {devices/bus_connect_nolab.sym} 2920 -920 2 0 {name=r68}
C {devices/bus_connect_nolab.sym} 2920 -940 2 0 {name=r69}
C {devices/bus_connect_nolab.sym} 2920 -960 2 0 {name=r70}
C {devices/bus_connect_nolab.sym} 2920 -980 2 0 {name=r71}
C {devices/bus_connect_nolab.sym} 2920 -1000 2 0 {name=r72}
C {devices/bus_connect_nolab.sym} 2920 -1020 2 0 {name=r73}
C {devices/bus_connect_nolab.sym} 2920 -1040 2 0 {name=r74}
C {devices/bus_connect_nolab.sym} 2920 -1060 2 0 {name=r75}
C {devices/bus_connect_nolab.sym} 2920 -1080 2 0 {name=r76}
C {devices/bus_connect_nolab.sym} 2920 -1100 2 0 {name=r77}
C {devices/bus_connect_nolab.sym} 2920 -1120 2 0 {name=r78}
C {devices/bus_connect_nolab.sym} 2920 -1140 2 0 {name=r79}
C {devices/bus_connect_nolab.sym} 2920 -1160 2 0 {name=r80}
C {devices/lab_wire.sym} 2980 -860 0 0 {name=l292 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -1160 0 0 {name=l293 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -1140 0 0 {name=l294 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -1120 0 0 {name=l295 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -1100 0 0 {name=l296 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -1080 0 0 {name=l297 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -1060 0 0 {name=l298 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -1040 0 0 {name=l299 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -1020 0 0 {name=l300 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -1000 0 0 {name=l301 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -980 0 0 {name=l302 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -960 0 0 {name=l303 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -940 0 0 {name=l304 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -920 0 0 {name=l384 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -900 0 0 {name=l385 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -880 0 0 {name=l386 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -820 0 0 {name=l387 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -860 2 0 {name=r81}
C {devices/bus_connect_nolab.sym} 3630 -880 2 0 {name=r82}
C {devices/bus_connect_nolab.sym} 3630 -900 2 0 {name=r83}
C {devices/bus_connect_nolab.sym} 3630 -920 2 0 {name=r84}
C {devices/bus_connect_nolab.sym} 3630 -940 2 0 {name=r85}
C {devices/bus_connect_nolab.sym} 3630 -960 2 0 {name=r86}
C {devices/bus_connect_nolab.sym} 3630 -980 2 0 {name=r87}
C {devices/bus_connect_nolab.sym} 3630 -1000 2 0 {name=r88}
C {devices/bus_connect_nolab.sym} 3630 -1020 2 0 {name=r89}
C {devices/bus_connect_nolab.sym} 3630 -1040 2 0 {name=r90}
C {devices/bus_connect_nolab.sym} 3630 -1060 2 0 {name=r91}
C {devices/bus_connect_nolab.sym} 3630 -1080 2 0 {name=r92}
C {devices/bus_connect_nolab.sym} 3630 -1100 2 0 {name=r93}
C {devices/bus_connect_nolab.sym} 3630 -1120 2 0 {name=r94}
C {devices/bus_connect_nolab.sym} 3630 -1140 2 0 {name=r95}
C {devices/bus_connect_nolab.sym} 3630 -1160 2 0 {name=r96}
C {devices/lab_wire.sym} 3690 -860 0 0 {name=l388 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} -760 -1380 2 0 {name=r193}
C {devices/bus_connect_nolab.sym} -760 -1360 2 0 {name=r194}
C {devices/bus_connect_nolab.sym} -760 -1340 2 0 {name=r195}
C {devices/lab_pin.sym} -770 -1350 0 0 {name=l965 sig_type=std_logic lab=RSEL[0..2]}
C {devices/lab_wire.sym} -710 -1380 0 0 {name=l966 sig_type=std_logic lab=RSEL0}
C {devices/lab_wire.sym} -710 -1360 0 0 {name=l967 sig_type=std_logic lab=RSEL1}
C {devices/lab_wire.sym} -710 -1340 0 0 {name=l968 sig_type=std_logic lab=RSEL2}
C {devices/bus_connect_nolab.sym} -760 -1660 2 0 {name=r196}
C {devices/bus_connect_nolab.sym} -760 -1640 2 0 {name=r197}
C {devices/bus_connect_nolab.sym} -760 -1620 2 0 {name=r198}
C {devices/lab_pin.sym} -770 -1630 0 0 {name=l969 sig_type=std_logic lab=CSEL[0..2]}
C {devices/lab_wire.sym} -710 -1660 0 0 {name=l4028 sig_type=std_logic lab=CSEL0}
C {devices/lab_wire.sym} -710 -1640 0 0 {name=l4029 sig_type=std_logic lab=CSEL1}
C {devices/lab_wire.sym} -710 -1620 0 0 {name=l4030 sig_type=std_logic lab=CSEL2}
C {devices/ipin.sym} -880 -1070 2 1 {name=p9 sig_type=std_logic lab=RSEL[0..2]}
C {devices/ipin.sym} -880 -1090 2 1 {name=p10 sig_type=std_logic lab=CSEL[0..2]}
C {devices/bus_connect_nolab.sym} 40 -1210 2 0 {name=r679}
C {devices/bus_connect_nolab.sym} 40 -1230 2 0 {name=r680}
C {devices/bus_connect_nolab.sym} 40 -1250 2 0 {name=r681}
C {devices/bus_connect_nolab.sym} 40 -1270 2 0 {name=r682}
C {devices/bus_connect_nolab.sym} 40 -1290 2 0 {name=r683}
C {devices/bus_connect_nolab.sym} 40 -1310 2 0 {name=r684}
C {devices/bus_connect_nolab.sym} 40 -1330 2 0 {name=r685}
C {devices/bus_connect_nolab.sym} 40 -1350 2 0 {name=r686}
C {devices/bus_connect_nolab.sym} 40 -1370 2 0 {name=r687}
C {devices/bus_connect_nolab.sym} 40 -1390 2 0 {name=r688}
C {devices/bus_connect_nolab.sym} 40 -1430 2 0 {name=r689}
C {devices/bus_connect_nolab.sym} 40 -1410 2 0 {name=r690}
C {devices/bus_connect_nolab.sym} 40 -1470 2 0 {name=r691}
C {devices/bus_connect_nolab.sym} 40 -1450 2 0 {name=r692}
C {devices/bus_connect_nolab.sym} 40 -1510 2 0 {name=r693}
C {devices/bus_connect_nolab.sym} 40 -1490 2 0 {name=r694}
C {devices/lab_wire.sym} 90 -1210 0 0 {name=l4061 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -1230 0 0 {name=l4062 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -1250 0 0 {name=l4063 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -1250 0 0 {name=l4064 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -1270 0 0 {name=l4065 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -1290 0 0 {name=l4066 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -1310 0 0 {name=l4067 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -1330 0 0 {name=l4068 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -1350 0 0 {name=l4069 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -1370 0 0 {name=l4070 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -1390 0 0 {name=l4071 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -1430 0 0 {name=l4072 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -1410 0 0 {name=l4073 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -1450 0 0 {name=l4074 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -1470 0 0 {name=l4075 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -1490 0 0 {name=l4076 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -1510 0 0 {name=l4077 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -1160 3 0 {name=l4078 sig_type=std_logic lab=rA[0..15]}
C {devices/ipin.sym} -880 -1040 2 1 {name=p12 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -1210 2 1 {name=r695}
C {devices/bus_connect_nolab.sym} 660 -1230 2 1 {name=r696}
C {devices/bus_connect_nolab.sym} 660 -1250 2 1 {name=r697}
C {devices/bus_connect_nolab.sym} 660 -1270 2 1 {name=r698}
C {devices/bus_connect_nolab.sym} 660 -1290 2 1 {name=r699}
C {devices/bus_connect_nolab.sym} 660 -1310 2 1 {name=r700}
C {devices/bus_connect_nolab.sym} 660 -1330 2 1 {name=r701}
C {devices/bus_connect_nolab.sym} 660 -1350 2 1 {name=r702}
C {devices/bus_connect_nolab.sym} 660 -1370 2 1 {name=r703}
C {devices/bus_connect_nolab.sym} 660 -1390 2 1 {name=r704}
C {devices/bus_connect_nolab.sym} 660 -1410 2 1 {name=r705}
C {devices/bus_connect_nolab.sym} 660 -1430 2 1 {name=r706}
C {devices/bus_connect_nolab.sym} 660 -1450 2 1 {name=r707}
C {devices/bus_connect_nolab.sym} 660 -1470 2 1 {name=r708}
C {devices/bus_connect_nolab.sym} 660 -1490 2 1 {name=r709}
C {devices/bus_connect_nolab.sym} 660 -1510 2 1 {name=r710}
C {devices/lab_pin.sym} 670 -1160 3 0 {name=l4079 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -1510 0 1 {name=l4080 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -1490 0 1 {name=l4081 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -1470 0 1 {name=l4082 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -1450 0 1 {name=l4083 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -1430 0 1 {name=l4084 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -1410 0 1 {name=l4085 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -1390 0 1 {name=l4086 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -1370 0 1 {name=l4087 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -1350 0 1 {name=l4088 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -1330 0 1 {name=l4089 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -1310 0 1 {name=l4090 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -1290 0 1 {name=l4091 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -1270 0 1 {name=l4092 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -1250 0 1 {name=l4093 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -1230 0 1 {name=l4094 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -1210 0 1 {name=l4095 sig_type=std_logic lab=rB0}
C {devices/ipin.sym} -880 -1020 2 1 {name=p13 sig_type=std_logic lab=rB[0..15]}
C {devices/ipin.sym} -880 -1000 2 1 {name=p14 sig_type=std_logic lab=cA[0..15]}
C {devices/ipin.sym} -880 -980 2 1 {name=p15 sig_type=std_logic lab=cB[0..15]}
C {devices/bus_connect_nolab.sym} 190 -530 2 0 {name=r711}
C {devices/bus_connect_nolab.sym} 190 -550 2 0 {name=r712}
C {devices/bus_connect_nolab.sym} 190 -570 2 0 {name=r713}
C {devices/bus_connect_nolab.sym} 190 -590 2 0 {name=r714}
C {devices/bus_connect_nolab.sym} 190 -610 2 0 {name=r715}
C {devices/bus_connect_nolab.sym} 190 -630 2 0 {name=r716}
C {devices/bus_connect_nolab.sym} 190 -650 2 0 {name=r717}
C {devices/bus_connect_nolab.sym} 190 -670 2 0 {name=r718}
C {devices/bus_connect_nolab.sym} 190 -690 2 0 {name=r719}
C {devices/bus_connect_nolab.sym} 190 -710 2 0 {name=r720}
C {devices/bus_connect_nolab.sym} 190 -730 2 0 {name=r721}
C {devices/bus_connect_nolab.sym} 190 -750 2 0 {name=r722}
C {devices/bus_connect_nolab.sym} 190 -770 2 0 {name=r723}
C {devices/bus_connect_nolab.sym} 190 -790 2 0 {name=r724}
C {devices/bus_connect_nolab.sym} 190 -810 2 0 {name=r725}
C {devices/bus_connect_nolab.sym} 190 -830 2 0 {name=r726}
C {devices/lab_pin.sym} 180 -490 3 0 {name=l4096 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -530 2 1 {name=r727}
C {devices/bus_connect_nolab.sym} 610 -550 2 1 {name=r728}
C {devices/bus_connect_nolab.sym} 610 -570 2 1 {name=r729}
C {devices/bus_connect_nolab.sym} 610 -590 2 1 {name=r730}
C {devices/bus_connect_nolab.sym} 610 -610 2 1 {name=r731}
C {devices/bus_connect_nolab.sym} 610 -630 2 1 {name=r732}
C {devices/bus_connect_nolab.sym} 610 -650 2 1 {name=r733}
C {devices/bus_connect_nolab.sym} 610 -670 2 1 {name=r734}
C {devices/bus_connect_nolab.sym} 610 -690 2 1 {name=r735}
C {devices/bus_connect_nolab.sym} 610 -710 2 1 {name=r736}
C {devices/bus_connect_nolab.sym} 610 -730 2 1 {name=r737}
C {devices/bus_connect_nolab.sym} 610 -750 2 1 {name=r738}
C {devices/bus_connect_nolab.sym} 610 -770 2 1 {name=r739}
C {devices/bus_connect_nolab.sym} 610 -790 2 1 {name=r740}
C {devices/bus_connect_nolab.sym} 610 -810 2 1 {name=r741}
C {devices/bus_connect_nolab.sym} 610 -830 2 1 {name=r742}
C {devices/lab_pin.sym} 620 -490 1 1 {name=l4097 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -550 0 0 {name=l4098 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -570 0 0 {name=l4099 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -590 0 0 {name=l4101 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -610 0 0 {name=l4102 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -630 0 0 {name=l4103 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -650 0 0 {name=l4104 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -670 0 0 {name=l4105 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -690 0 0 {name=l4106 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -710 0 0 {name=l4107 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -750 0 0 {name=l4108 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -730 0 0 {name=l4109 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -770 0 0 {name=l4110 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -790 0 0 {name=l4111 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -810 0 0 {name=l4112 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -830 0 0 {name=l4113 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -530 0 0 {name=l4114 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -550 0 1 {name=l4100 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -570 0 1 {name=l4115 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -590 0 1 {name=l4116 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -610 0 1 {name=l4117 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -630 0 1 {name=l4118 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -650 0 1 {name=l4119 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -670 0 1 {name=l4120 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -690 0 1 {name=l4121 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -710 0 1 {name=l4122 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -750 0 1 {name=l4123 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -730 0 1 {name=l4124 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -770 0 1 {name=l4125 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -790 0 1 {name=l4126 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -810 0 1 {name=l4127 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -830 0 1 {name=l4128 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -530 0 1 {name=l4129 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -1810 0 0 {name=l4 lab=row0_sel}
C {devices/lab_pin.sym} 910 -1790 0 0 {name=l147 lab=col1_sel}
C {devices/opin.sym} 1330 -1810 2 1 {name=p34 lab=latch_high1}
C {devices/bus_connect_nolab.sym} 760 -1210 2 0 {name=r743}
C {devices/bus_connect_nolab.sym} 760 -1230 2 0 {name=r744}
C {devices/bus_connect_nolab.sym} 760 -1250 2 0 {name=r745}
C {devices/bus_connect_nolab.sym} 760 -1270 2 0 {name=r746}
C {devices/bus_connect_nolab.sym} 760 -1290 2 0 {name=r747}
C {devices/bus_connect_nolab.sym} 760 -1310 2 0 {name=r748}
C {devices/bus_connect_nolab.sym} 760 -1330 2 0 {name=r749}
C {devices/bus_connect_nolab.sym} 760 -1350 2 0 {name=r750}
C {devices/bus_connect_nolab.sym} 760 -1370 2 0 {name=r751}
C {devices/bus_connect_nolab.sym} 760 -1390 2 0 {name=r752}
C {devices/bus_connect_nolab.sym} 760 -1430 2 0 {name=r753}
C {devices/bus_connect_nolab.sym} 760 -1410 2 0 {name=r754}
C {devices/bus_connect_nolab.sym} 760 -1470 2 0 {name=r755}
C {devices/bus_connect_nolab.sym} 760 -1450 2 0 {name=r756}
C {devices/bus_connect_nolab.sym} 760 -1510 2 0 {name=r757}
C {devices/bus_connect_nolab.sym} 760 -1490 2 0 {name=r758}
C {devices/lab_wire.sym} 810 -1210 0 0 {name=l149 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -1230 0 0 {name=l150 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -1250 0 0 {name=l151 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -1250 0 0 {name=l152 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -1270 0 0 {name=l154 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -1290 0 0 {name=l160 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -1310 0 0 {name=l161 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -1330 0 0 {name=l162 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -1350 0 0 {name=l163 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -1370 0 0 {name=l164 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -1390 0 0 {name=l165 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -1430 0 0 {name=l166 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -1410 0 0 {name=l167 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -1450 0 0 {name=l168 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -1470 0 0 {name=l169 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -1490 0 0 {name=l170 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -1510 0 0 {name=l171 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -1160 3 0 {name=l172 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -1210 2 1 {name=r759}
C {devices/bus_connect_nolab.sym} 1380 -1230 2 1 {name=r760}
C {devices/bus_connect_nolab.sym} 1380 -1250 2 1 {name=r761}
C {devices/bus_connect_nolab.sym} 1380 -1270 2 1 {name=r762}
C {devices/bus_connect_nolab.sym} 1380 -1290 2 1 {name=r763}
C {devices/bus_connect_nolab.sym} 1380 -1310 2 1 {name=r764}
C {devices/bus_connect_nolab.sym} 1380 -1330 2 1 {name=r765}
C {devices/bus_connect_nolab.sym} 1380 -1350 2 1 {name=r766}
C {devices/bus_connect_nolab.sym} 1380 -1370 2 1 {name=r767}
C {devices/bus_connect_nolab.sym} 1380 -1390 2 1 {name=r768}
C {devices/bus_connect_nolab.sym} 1380 -1410 2 1 {name=r769}
C {devices/bus_connect_nolab.sym} 1380 -1430 2 1 {name=r770}
C {devices/bus_connect_nolab.sym} 1380 -1450 2 1 {name=r771}
C {devices/bus_connect_nolab.sym} 1380 -1470 2 1 {name=r772}
C {devices/bus_connect_nolab.sym} 1380 -1490 2 1 {name=r773}
C {devices/bus_connect_nolab.sym} 1380 -1510 2 1 {name=r774}
C {devices/lab_pin.sym} 1390 -1160 3 0 {name=l173 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -1510 0 1 {name=l174 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -1490 0 1 {name=l175 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -1470 0 1 {name=l176 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -1450 0 1 {name=l177 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -1430 0 1 {name=l178 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -1410 0 1 {name=l179 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -1390 0 1 {name=l180 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -1370 0 1 {name=l181 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -1350 0 1 {name=l182 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -1330 0 1 {name=l183 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -1310 0 1 {name=l184 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -1290 0 1 {name=l185 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -1270 0 1 {name=l186 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -1250 0 1 {name=l187 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -1230 0 1 {name=l188 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -1210 0 1 {name=l189 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -1730 0 0 {name=l52 lab=Vgpr}
C {devices/lab_pin.sym} 910 -1770 0 0 {name=l53 lab=Vgnr}
C {devices/lab_pin.sym} 910 -1750 0 0 {name=l54 lab=WR}
C {devices/lab_pin.sym} 910 -1670 2 1 {name=l190 lab=Vrplus}
C {devices/lab_pin.sym} 910 -1610 0 0 {name=l191 lab=Vref}
C {devices/lab_pin.sym} 910 -1570 0 0 {name=l3964 lab=Vcplus}
C {devices/lab_pin.sym} 910 -1590 0 0 {name=l4130 lab=Vcminus}
C {devices/lab_pin.sym} 910 -1630 2 1 {name=l4131 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -1650 2 1 {name=l4132 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -1770 2 0 {name=l4133 lab=vdda1}
C {devices/lab_pin.sym} 1330 -1790 2 0 {name=l4135 lab=vccd1}
C {devices/lab_pin.sym} 1610 -1680 2 1 {name=l5 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -1700 0 0 {name=l6 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -1800 0 0 {name=l7 lab=row0_sel}
C {devices/lab_pin.sym} 1610 -1780 0 0 {name=l69 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -1720 0 0 {name=l70 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -1760 0 0 {name=l72 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -1740 0 0 {name=l73 lab=WR}
C {devices/lab_pin.sym} 1610 -1660 2 1 {name=l81 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -1600 0 0 {name=l82 lab=Vref}
C {devices/lab_pin.sym} 1610 -1560 0 0 {name=l83 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -1580 0 0 {name=l84 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -1620 2 1 {name=l85 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -1640 2 1 {name=l86 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -1760 2 0 {name=l87 lab=vdda1}
C {devices/lab_pin.sym} 2030 -1780 2 0 {name=l89 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -1200 2 0 {name=r775}
C {devices/bus_connect_nolab.sym} 1460 -1220 2 0 {name=r776}
C {devices/bus_connect_nolab.sym} 1460 -1240 2 0 {name=r777}
C {devices/bus_connect_nolab.sym} 1460 -1260 2 0 {name=r778}
C {devices/bus_connect_nolab.sym} 1460 -1280 2 0 {name=r779}
C {devices/bus_connect_nolab.sym} 1460 -1300 2 0 {name=r780}
C {devices/bus_connect_nolab.sym} 1460 -1320 2 0 {name=r781}
C {devices/bus_connect_nolab.sym} 1460 -1340 2 0 {name=r782}
C {devices/bus_connect_nolab.sym} 1460 -1360 2 0 {name=r783}
C {devices/bus_connect_nolab.sym} 1460 -1380 2 0 {name=r784}
C {devices/bus_connect_nolab.sym} 1460 -1420 2 0 {name=r785}
C {devices/bus_connect_nolab.sym} 1460 -1400 2 0 {name=r786}
C {devices/bus_connect_nolab.sym} 1460 -1460 2 0 {name=r787}
C {devices/bus_connect_nolab.sym} 1460 -1440 2 0 {name=r788}
C {devices/bus_connect_nolab.sym} 1460 -1500 2 0 {name=r789}
C {devices/bus_connect_nolab.sym} 1460 -1480 2 0 {name=r790}
C {devices/lab_wire.sym} 1510 -1200 0 0 {name=l90 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -1220 0 0 {name=l91 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -1240 0 0 {name=l92 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -1240 0 0 {name=l93 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -1260 0 0 {name=l94 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -1280 0 0 {name=l95 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -1300 0 0 {name=l96 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -1320 0 0 {name=l97 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -1340 0 0 {name=l98 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -1360 0 0 {name=l99 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -1380 0 0 {name=l100 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -1420 0 0 {name=l101 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -1400 0 0 {name=l102 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -1440 0 0 {name=l103 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -1460 0 0 {name=l104 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -1480 0 0 {name=l105 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -1500 0 0 {name=l106 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -1150 3 0 {name=l107 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -1200 2 1 {name=r791}
C {devices/bus_connect_nolab.sym} 2080 -1220 2 1 {name=r792}
C {devices/bus_connect_nolab.sym} 2080 -1240 2 1 {name=r793}
C {devices/bus_connect_nolab.sym} 2080 -1260 2 1 {name=r794}
C {devices/bus_connect_nolab.sym} 2080 -1280 2 1 {name=r795}
C {devices/bus_connect_nolab.sym} 2080 -1300 2 1 {name=r796}
C {devices/bus_connect_nolab.sym} 2080 -1320 2 1 {name=r797}
C {devices/bus_connect_nolab.sym} 2080 -1340 2 1 {name=r798}
C {devices/bus_connect_nolab.sym} 2080 -1360 2 1 {name=r799}
C {devices/bus_connect_nolab.sym} 2080 -1380 2 1 {name=r800}
C {devices/bus_connect_nolab.sym} 2080 -1400 2 1 {name=r801}
C {devices/bus_connect_nolab.sym} 2080 -1420 2 1 {name=r802}
C {devices/bus_connect_nolab.sym} 2080 -1440 2 1 {name=r803}
C {devices/bus_connect_nolab.sym} 2080 -1460 2 1 {name=r804}
C {devices/bus_connect_nolab.sym} 2080 -1480 2 1 {name=r805}
C {devices/bus_connect_nolab.sym} 2080 -1500 2 1 {name=r806}
C {devices/lab_pin.sym} 2090 -1150 3 0 {name=l108 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -1500 0 1 {name=l109 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -1480 0 1 {name=l110 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -1460 0 1 {name=l111 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -1440 0 1 {name=l133 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -1420 0 1 {name=l148 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -1400 0 1 {name=l3974 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -1380 0 1 {name=l4136 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -1360 0 1 {name=l4137 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -1340 0 1 {name=l4138 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -1320 0 1 {name=l4139 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -1300 0 1 {name=l4140 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -1280 0 1 {name=l4141 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -1260 0 1 {name=l4142 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -1240 0 1 {name=l4143 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -1220 0 1 {name=l4144 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -1200 0 1 {name=l4145 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -530 2 0 {name=r807}
C {devices/bus_connect_nolab.sym} 910 -550 2 0 {name=r808}
C {devices/bus_connect_nolab.sym} 910 -570 2 0 {name=r809}
C {devices/bus_connect_nolab.sym} 910 -590 2 0 {name=r810}
C {devices/bus_connect_nolab.sym} 910 -610 2 0 {name=r811}
C {devices/bus_connect_nolab.sym} 910 -630 2 0 {name=r812}
C {devices/bus_connect_nolab.sym} 910 -650 2 0 {name=r813}
C {devices/bus_connect_nolab.sym} 910 -670 2 0 {name=r814}
C {devices/bus_connect_nolab.sym} 910 -690 2 0 {name=r815}
C {devices/bus_connect_nolab.sym} 910 -710 2 0 {name=r816}
C {devices/bus_connect_nolab.sym} 910 -730 2 0 {name=r817}
C {devices/bus_connect_nolab.sym} 910 -750 2 0 {name=r818}
C {devices/bus_connect_nolab.sym} 910 -770 2 0 {name=r819}
C {devices/bus_connect_nolab.sym} 910 -790 2 0 {name=r820}
C {devices/bus_connect_nolab.sym} 910 -810 2 0 {name=r821}
C {devices/bus_connect_nolab.sym} 910 -830 2 0 {name=r822}
C {devices/lab_pin.sym} 900 -490 3 0 {name=l24 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -530 2 1 {name=r823}
C {devices/bus_connect_nolab.sym} 1330 -550 2 1 {name=r824}
C {devices/bus_connect_nolab.sym} 1330 -570 2 1 {name=r825}
C {devices/bus_connect_nolab.sym} 1330 -590 2 1 {name=r826}
C {devices/bus_connect_nolab.sym} 1330 -610 2 1 {name=r827}
C {devices/bus_connect_nolab.sym} 1330 -630 2 1 {name=r828}
C {devices/bus_connect_nolab.sym} 1330 -650 2 1 {name=r829}
C {devices/bus_connect_nolab.sym} 1330 -670 2 1 {name=r830}
C {devices/bus_connect_nolab.sym} 1330 -690 2 1 {name=r831}
C {devices/bus_connect_nolab.sym} 1330 -710 2 1 {name=r832}
C {devices/bus_connect_nolab.sym} 1330 -730 2 1 {name=r833}
C {devices/bus_connect_nolab.sym} 1330 -750 2 1 {name=r834}
C {devices/bus_connect_nolab.sym} 1330 -770 2 1 {name=r835}
C {devices/bus_connect_nolab.sym} 1330 -790 2 1 {name=r836}
C {devices/bus_connect_nolab.sym} 1330 -810 2 1 {name=r837}
C {devices/bus_connect_nolab.sym} 1330 -830 2 1 {name=r838}
C {devices/lab_pin.sym} 1340 -490 1 1 {name=l25 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -550 0 0 {name=l26 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -570 0 0 {name=l27 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -590 0 0 {name=l28 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -610 0 0 {name=l29 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -630 0 0 {name=l30 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -650 0 0 {name=l31 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -670 0 0 {name=l32 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -690 0 0 {name=l33 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -710 0 0 {name=l34 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -750 0 0 {name=l35 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -730 0 0 {name=l36 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -770 0 0 {name=l37 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -790 0 0 {name=l38 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -810 0 0 {name=l39 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -830 0 0 {name=l40 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -530 0 0 {name=l41 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -550 0 1 {name=l42 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -570 0 1 {name=l43 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -590 0 1 {name=l44 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -610 0 1 {name=l45 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -630 0 1 {name=l46 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -650 0 1 {name=l47 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -670 0 1 {name=l48 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -690 0 1 {name=l49 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -710 0 1 {name=l50 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -750 0 1 {name=l51 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -730 0 1 {name=l59 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -770 0 1 {name=l66 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -790 0 1 {name=l67 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -810 0 1 {name=l68 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -830 0 1 {name=l75 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -530 0 1 {name=l76 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -520 2 0 {name=r839}
C {devices/bus_connect_nolab.sym} 1610 -540 2 0 {name=r840}
C {devices/bus_connect_nolab.sym} 1610 -560 2 0 {name=r841}
C {devices/bus_connect_nolab.sym} 1610 -580 2 0 {name=r842}
C {devices/bus_connect_nolab.sym} 1610 -600 2 0 {name=r843}
C {devices/bus_connect_nolab.sym} 1610 -620 2 0 {name=r844}
C {devices/bus_connect_nolab.sym} 1610 -640 2 0 {name=r845}
C {devices/bus_connect_nolab.sym} 1610 -660 2 0 {name=r846}
C {devices/bus_connect_nolab.sym} 1610 -680 2 0 {name=r847}
C {devices/bus_connect_nolab.sym} 1610 -700 2 0 {name=r848}
C {devices/bus_connect_nolab.sym} 1610 -720 2 0 {name=r849}
C {devices/bus_connect_nolab.sym} 1610 -740 2 0 {name=r850}
C {devices/bus_connect_nolab.sym} 1610 -760 2 0 {name=r851}
C {devices/bus_connect_nolab.sym} 1610 -780 2 0 {name=r852}
C {devices/bus_connect_nolab.sym} 1610 -800 2 0 {name=r853}
C {devices/bus_connect_nolab.sym} 1610 -820 2 0 {name=r854}
C {devices/lab_pin.sym} 1600 -480 3 0 {name=l77 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -520 2 1 {name=r855}
C {devices/bus_connect_nolab.sym} 2030 -540 2 1 {name=r856}
C {devices/bus_connect_nolab.sym} 2030 -560 2 1 {name=r857}
C {devices/bus_connect_nolab.sym} 2030 -580 2 1 {name=r858}
C {devices/bus_connect_nolab.sym} 2030 -600 2 1 {name=r859}
C {devices/bus_connect_nolab.sym} 2030 -620 2 1 {name=r860}
C {devices/bus_connect_nolab.sym} 2030 -640 2 1 {name=r861}
C {devices/bus_connect_nolab.sym} 2030 -660 2 1 {name=r862}
C {devices/bus_connect_nolab.sym} 2030 -680 2 1 {name=r863}
C {devices/bus_connect_nolab.sym} 2030 -700 2 1 {name=r864}
C {devices/bus_connect_nolab.sym} 2030 -720 2 1 {name=r865}
C {devices/bus_connect_nolab.sym} 2030 -740 2 1 {name=r866}
C {devices/bus_connect_nolab.sym} 2030 -760 2 1 {name=r867}
C {devices/bus_connect_nolab.sym} 2030 -780 2 1 {name=r868}
C {devices/bus_connect_nolab.sym} 2030 -800 2 1 {name=r869}
C {devices/bus_connect_nolab.sym} 2030 -820 2 1 {name=r870}
C {devices/lab_pin.sym} 2040 -480 1 1 {name=l79 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -540 0 0 {name=l80 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -560 0 0 {name=l114 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -580 0 0 {name=l115 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -600 0 0 {name=l116 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -620 0 0 {name=l117 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -640 0 0 {name=l118 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -660 0 0 {name=l119 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -680 0 0 {name=l120 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -700 0 0 {name=l121 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -740 0 0 {name=l122 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -720 0 0 {name=l123 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -760 0 0 {name=l124 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -780 0 0 {name=l125 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -800 0 0 {name=l126 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -820 0 0 {name=l127 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -520 0 0 {name=l128 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -540 0 1 {name=l129 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -560 0 1 {name=l130 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -580 0 1 {name=l131 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -600 0 1 {name=l132 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -620 0 1 {name=l134 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -640 0 1 {name=l135 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -660 0 1 {name=l136 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -680 0 1 {name=l137 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -700 0 1 {name=l138 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -740 0 1 {name=l139 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -720 0 1 {name=l140 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -760 0 1 {name=l141 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -780 0 1 {name=l142 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -800 0 1 {name=l143 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -820 0 1 {name=l144 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -520 0 1 {name=l145 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -1210 2 0 {name=r871}
C {devices/bus_connect_nolab.sym} 2190 -1230 2 0 {name=r872}
C {devices/bus_connect_nolab.sym} 2190 -1250 2 0 {name=r873}
C {devices/bus_connect_nolab.sym} 2190 -1270 2 0 {name=r874}
C {devices/bus_connect_nolab.sym} 2190 -1290 2 0 {name=r875}
C {devices/bus_connect_nolab.sym} 2190 -1310 2 0 {name=r876}
C {devices/bus_connect_nolab.sym} 2190 -1330 2 0 {name=r877}
C {devices/bus_connect_nolab.sym} 2190 -1350 2 0 {name=r878}
C {devices/bus_connect_nolab.sym} 2190 -1370 2 0 {name=r879}
C {devices/bus_connect_nolab.sym} 2190 -1390 2 0 {name=r880}
C {devices/bus_connect_nolab.sym} 2190 -1430 2 0 {name=r881}
C {devices/bus_connect_nolab.sym} 2190 -1410 2 0 {name=r882}
C {devices/bus_connect_nolab.sym} 2190 -1470 2 0 {name=r883}
C {devices/bus_connect_nolab.sym} 2190 -1450 2 0 {name=r884}
C {devices/bus_connect_nolab.sym} 2190 -1510 2 0 {name=r885}
C {devices/bus_connect_nolab.sym} 2190 -1490 2 0 {name=r886}
C {devices/lab_wire.sym} 2240 -1210 0 0 {name=l146 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -1230 0 0 {name=l155 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -1250 0 0 {name=l156 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -1250 0 0 {name=l157 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -1270 0 0 {name=l158 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -1290 0 0 {name=l159 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -1310 0 0 {name=l210 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -1330 0 0 {name=l211 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -1350 0 0 {name=l212 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -1370 0 0 {name=l213 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -1390 0 0 {name=l214 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -1430 0 0 {name=l215 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -1410 0 0 {name=l216 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -1450 0 0 {name=l217 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -1470 0 0 {name=l218 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -1490 0 0 {name=l219 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -1510 0 0 {name=l220 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -1160 3 0 {name=l221 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -1210 2 1 {name=r887}
C {devices/bus_connect_nolab.sym} 2810 -1230 2 1 {name=r888}
C {devices/bus_connect_nolab.sym} 2810 -1250 2 1 {name=r889}
C {devices/bus_connect_nolab.sym} 2810 -1270 2 1 {name=r890}
C {devices/bus_connect_nolab.sym} 2810 -1290 2 1 {name=r891}
C {devices/bus_connect_nolab.sym} 2810 -1310 2 1 {name=r892}
C {devices/bus_connect_nolab.sym} 2810 -1330 2 1 {name=r893}
C {devices/bus_connect_nolab.sym} 2810 -1350 2 1 {name=r894}
C {devices/bus_connect_nolab.sym} 2810 -1370 2 1 {name=r895}
C {devices/bus_connect_nolab.sym} 2810 -1390 2 1 {name=r896}
C {devices/bus_connect_nolab.sym} 2810 -1410 2 1 {name=r897}
C {devices/bus_connect_nolab.sym} 2810 -1430 2 1 {name=r898}
C {devices/bus_connect_nolab.sym} 2810 -1450 2 1 {name=r899}
C {devices/bus_connect_nolab.sym} 2810 -1470 2 1 {name=r900}
C {devices/bus_connect_nolab.sym} 2810 -1490 2 1 {name=r901}
C {devices/bus_connect_nolab.sym} 2810 -1510 2 1 {name=r902}
C {devices/lab_pin.sym} 2820 -1160 3 0 {name=l222 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -1510 0 1 {name=l223 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -1490 0 1 {name=l224 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -1470 0 1 {name=l225 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -1450 0 1 {name=l226 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -1430 0 1 {name=l227 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -1410 0 1 {name=l228 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -1390 0 1 {name=l229 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -1370 0 1 {name=l230 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -1350 0 1 {name=l231 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -1330 0 1 {name=l232 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -1310 0 1 {name=l233 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -1290 0 1 {name=l234 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -1270 0 1 {name=l235 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -1250 0 1 {name=l236 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -1230 0 1 {name=l237 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -1210 0 1 {name=l238 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -530 2 0 {name=r903}
C {devices/bus_connect_nolab.sym} 2340 -550 2 0 {name=r904}
C {devices/bus_connect_nolab.sym} 2340 -570 2 0 {name=r905}
C {devices/bus_connect_nolab.sym} 2340 -590 2 0 {name=r906}
C {devices/bus_connect_nolab.sym} 2340 -610 2 0 {name=r907}
C {devices/bus_connect_nolab.sym} 2340 -630 2 0 {name=r908}
C {devices/bus_connect_nolab.sym} 2340 -650 2 0 {name=r909}
C {devices/bus_connect_nolab.sym} 2340 -670 2 0 {name=r910}
C {devices/bus_connect_nolab.sym} 2340 -690 2 0 {name=r911}
C {devices/bus_connect_nolab.sym} 2340 -710 2 0 {name=r912}
C {devices/bus_connect_nolab.sym} 2340 -730 2 0 {name=r913}
C {devices/bus_connect_nolab.sym} 2340 -750 2 0 {name=r914}
C {devices/bus_connect_nolab.sym} 2340 -770 2 0 {name=r915}
C {devices/bus_connect_nolab.sym} 2340 -790 2 0 {name=r916}
C {devices/bus_connect_nolab.sym} 2340 -810 2 0 {name=r917}
C {devices/bus_connect_nolab.sym} 2340 -830 2 0 {name=r918}
C {devices/lab_pin.sym} 2330 -490 3 0 {name=l239 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -530 2 1 {name=r919}
C {devices/bus_connect_nolab.sym} 2760 -550 2 1 {name=r920}
C {devices/bus_connect_nolab.sym} 2760 -570 2 1 {name=r921}
C {devices/bus_connect_nolab.sym} 2760 -590 2 1 {name=r922}
C {devices/bus_connect_nolab.sym} 2760 -610 2 1 {name=r923}
C {devices/bus_connect_nolab.sym} 2760 -630 2 1 {name=r924}
C {devices/bus_connect_nolab.sym} 2760 -650 2 1 {name=r925}
C {devices/bus_connect_nolab.sym} 2760 -670 2 1 {name=r926}
C {devices/bus_connect_nolab.sym} 2760 -690 2 1 {name=r927}
C {devices/bus_connect_nolab.sym} 2760 -710 2 1 {name=r928}
C {devices/bus_connect_nolab.sym} 2760 -730 2 1 {name=r929}
C {devices/bus_connect_nolab.sym} 2760 -750 2 1 {name=r930}
C {devices/bus_connect_nolab.sym} 2760 -770 2 1 {name=r931}
C {devices/bus_connect_nolab.sym} 2760 -790 2 1 {name=r932}
C {devices/bus_connect_nolab.sym} 2760 -810 2 1 {name=r933}
C {devices/bus_connect_nolab.sym} 2760 -830 2 1 {name=r934}
C {devices/lab_pin.sym} 2770 -490 1 1 {name=l240 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -550 0 0 {name=l241 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -570 0 0 {name=l242 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -590 0 0 {name=l243 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -610 0 0 {name=l244 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -630 0 0 {name=l245 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -650 0 0 {name=l246 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -670 0 0 {name=l247 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -690 0 0 {name=l248 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -710 0 0 {name=l249 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -750 0 0 {name=l250 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -730 0 0 {name=l251 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -770 0 0 {name=l252 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -790 0 0 {name=l253 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -810 0 0 {name=l254 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -830 0 0 {name=l255 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -530 0 0 {name=l256 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -550 0 1 {name=l257 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -570 0 1 {name=l258 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -590 0 1 {name=l259 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -610 0 1 {name=l260 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -630 0 1 {name=l261 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -650 0 1 {name=l262 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -670 0 1 {name=l263 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -690 0 1 {name=l264 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -710 0 1 {name=l265 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -750 0 1 {name=l266 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -730 0 1 {name=l267 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -770 0 1 {name=l268 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -790 0 1 {name=l269 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -810 0 1 {name=l270 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -830 0 1 {name=l271 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -530 0 1 {name=l272 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -1200 2 0 {name=r935}
C {devices/bus_connect_nolab.sym} 2890 -1220 2 0 {name=r936}
C {devices/bus_connect_nolab.sym} 2890 -1240 2 0 {name=r937}
C {devices/bus_connect_nolab.sym} 2890 -1260 2 0 {name=r938}
C {devices/bus_connect_nolab.sym} 2890 -1280 2 0 {name=r939}
C {devices/bus_connect_nolab.sym} 2890 -1300 2 0 {name=r940}
C {devices/bus_connect_nolab.sym} 2890 -1320 2 0 {name=r941}
C {devices/bus_connect_nolab.sym} 2890 -1340 2 0 {name=r942}
C {devices/bus_connect_nolab.sym} 2890 -1360 2 0 {name=r943}
C {devices/bus_connect_nolab.sym} 2890 -1380 2 0 {name=r944}
C {devices/bus_connect_nolab.sym} 2890 -1420 2 0 {name=r945}
C {devices/bus_connect_nolab.sym} 2890 -1400 2 0 {name=r946}
C {devices/bus_connect_nolab.sym} 2890 -1460 2 0 {name=r947}
C {devices/bus_connect_nolab.sym} 2890 -1440 2 0 {name=r948}
C {devices/bus_connect_nolab.sym} 2890 -1500 2 0 {name=r949}
C {devices/bus_connect_nolab.sym} 2890 -1480 2 0 {name=r950}
C {devices/lab_wire.sym} 2940 -1200 0 0 {name=l273 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -1220 0 0 {name=l274 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -1240 0 0 {name=l275 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -1240 0 0 {name=l276 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -1260 0 0 {name=l277 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -1280 0 0 {name=l278 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -1300 0 0 {name=l279 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -1320 0 0 {name=l280 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -1340 0 0 {name=l281 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -1360 0 0 {name=l282 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -1380 0 0 {name=l283 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -1420 0 0 {name=l284 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -1400 0 0 {name=l285 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -1440 0 0 {name=l305 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -1460 0 0 {name=l306 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -1480 0 0 {name=l307 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -1500 0 0 {name=l308 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -1150 3 0 {name=l309 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -1200 2 1 {name=r951}
C {devices/bus_connect_nolab.sym} 3510 -1220 2 1 {name=r952}
C {devices/bus_connect_nolab.sym} 3510 -1240 2 1 {name=r953}
C {devices/bus_connect_nolab.sym} 3510 -1260 2 1 {name=r954}
C {devices/bus_connect_nolab.sym} 3510 -1280 2 1 {name=r955}
C {devices/bus_connect_nolab.sym} 3510 -1300 2 1 {name=r956}
C {devices/bus_connect_nolab.sym} 3510 -1320 2 1 {name=r957}
C {devices/bus_connect_nolab.sym} 3510 -1340 2 1 {name=r958}
C {devices/bus_connect_nolab.sym} 3510 -1360 2 1 {name=r959}
C {devices/bus_connect_nolab.sym} 3510 -1380 2 1 {name=r960}
C {devices/bus_connect_nolab.sym} 3510 -1400 2 1 {name=r961}
C {devices/bus_connect_nolab.sym} 3510 -1420 2 1 {name=r962}
C {devices/bus_connect_nolab.sym} 3510 -1440 2 1 {name=r963}
C {devices/bus_connect_nolab.sym} 3510 -1460 2 1 {name=r964}
C {devices/bus_connect_nolab.sym} 3510 -1480 2 1 {name=r965}
C {devices/bus_connect_nolab.sym} 3510 -1500 2 1 {name=r966}
C {devices/lab_pin.sym} 3520 -1150 3 0 {name=l310 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -1500 0 1 {name=l311 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -1480 0 1 {name=l312 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -1460 0 1 {name=l313 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -1440 0 1 {name=l314 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -1420 0 1 {name=l315 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -1400 0 1 {name=l316 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -1380 0 1 {name=l317 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -1360 0 1 {name=l318 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -1340 0 1 {name=l319 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -1320 0 1 {name=l320 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -1300 0 1 {name=l321 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -1280 0 1 {name=l322 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -1260 0 1 {name=l323 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -1240 0 1 {name=l324 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -1220 0 1 {name=l325 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -1200 0 1 {name=l326 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -520 2 0 {name=r967}
C {devices/bus_connect_nolab.sym} 3040 -540 2 0 {name=r968}
C {devices/bus_connect_nolab.sym} 3040 -560 2 0 {name=r969}
C {devices/bus_connect_nolab.sym} 3040 -580 2 0 {name=r970}
C {devices/bus_connect_nolab.sym} 3040 -600 2 0 {name=r971}
C {devices/bus_connect_nolab.sym} 3040 -620 2 0 {name=r972}
C {devices/bus_connect_nolab.sym} 3040 -640 2 0 {name=r973}
C {devices/bus_connect_nolab.sym} 3040 -660 2 0 {name=r974}
C {devices/bus_connect_nolab.sym} 3040 -680 2 0 {name=r975}
C {devices/bus_connect_nolab.sym} 3040 -700 2 0 {name=r976}
C {devices/bus_connect_nolab.sym} 3040 -720 2 0 {name=r977}
C {devices/bus_connect_nolab.sym} 3040 -740 2 0 {name=r978}
C {devices/bus_connect_nolab.sym} 3040 -760 2 0 {name=r979}
C {devices/bus_connect_nolab.sym} 3040 -780 2 0 {name=r980}
C {devices/bus_connect_nolab.sym} 3040 -800 2 0 {name=r981}
C {devices/bus_connect_nolab.sym} 3040 -820 2 0 {name=r982}
C {devices/lab_pin.sym} 3030 -480 3 0 {name=l327 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 3460 -520 2 1 {name=r983}
C {devices/bus_connect_nolab.sym} 3460 -540 2 1 {name=r984}
C {devices/bus_connect_nolab.sym} 3460 -560 2 1 {name=r985}
C {devices/bus_connect_nolab.sym} 3460 -580 2 1 {name=r986}
C {devices/bus_connect_nolab.sym} 3460 -600 2 1 {name=r987}
C {devices/bus_connect_nolab.sym} 3460 -620 2 1 {name=r988}
C {devices/bus_connect_nolab.sym} 3460 -640 2 1 {name=r989}
C {devices/bus_connect_nolab.sym} 3460 -660 2 1 {name=r990}
C {devices/bus_connect_nolab.sym} 3460 -680 2 1 {name=r991}
C {devices/bus_connect_nolab.sym} 3460 -700 2 1 {name=r992}
C {devices/bus_connect_nolab.sym} 3460 -720 2 1 {name=r993}
C {devices/bus_connect_nolab.sym} 3460 -740 2 1 {name=r994}
C {devices/bus_connect_nolab.sym} 3460 -760 2 1 {name=r995}
C {devices/bus_connect_nolab.sym} 3460 -780 2 1 {name=r996}
C {devices/bus_connect_nolab.sym} 3460 -800 2 1 {name=r997}
C {devices/bus_connect_nolab.sym} 3460 -820 2 1 {name=r998}
C {devices/lab_pin.sym} 3470 -480 1 1 {name=l328 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3080 -540 0 0 {name=l329 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3080 -560 0 0 {name=l330 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3080 -580 0 0 {name=l331 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3080 -600 0 0 {name=l332 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3080 -620 0 0 {name=l333 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3080 -640 0 0 {name=l334 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3080 -660 0 0 {name=l335 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3080 -680 0 0 {name=l336 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3080 -700 0 0 {name=l337 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3080 -740 0 0 {name=l338 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3080 -720 0 0 {name=l339 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3080 -760 0 0 {name=l340 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3080 -780 0 0 {name=l341 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3080 -800 0 0 {name=l342 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3080 -820 0 0 {name=l343 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3080 -520 0 0 {name=l344 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 3420 -540 0 1 {name=l345 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 3420 -560 0 1 {name=l346 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 3420 -580 0 1 {name=l347 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 3420 -600 0 1 {name=l348 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 3420 -620 0 1 {name=l349 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 3420 -640 0 1 {name=l350 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 3420 -660 0 1 {name=l351 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 3420 -680 0 1 {name=l352 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 3420 -700 0 1 {name=l353 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 3420 -740 0 1 {name=l354 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 3420 -720 0 1 {name=l355 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 3420 -760 0 1 {name=l356 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 3420 -780 0 1 {name=l357 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 3420 -800 0 1 {name=l358 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 3420 -820 0 1 {name=l359 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 3420 -520 0 1 {name=l360 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 3600 -1200 2 0 {name=r999}
C {devices/bus_connect_nolab.sym} 3600 -1220 2 0 {name=r1000}
C {devices/bus_connect_nolab.sym} 3600 -1240 2 0 {name=r1001}
C {devices/bus_connect_nolab.sym} 3600 -1260 2 0 {name=r1002}
C {devices/bus_connect_nolab.sym} 3600 -1280 2 0 {name=r1003}
C {devices/bus_connect_nolab.sym} 3600 -1300 2 0 {name=r1004}
C {devices/bus_connect_nolab.sym} 3600 -1320 2 0 {name=r1005}
C {devices/bus_connect_nolab.sym} 3600 -1340 2 0 {name=r1006}
C {devices/bus_connect_nolab.sym} 3600 -1360 2 0 {name=r1007}
C {devices/bus_connect_nolab.sym} 3600 -1380 2 0 {name=r1008}
C {devices/bus_connect_nolab.sym} 3600 -1420 2 0 {name=r1009}
C {devices/bus_connect_nolab.sym} 3600 -1400 2 0 {name=r1010}
C {devices/bus_connect_nolab.sym} 3600 -1460 2 0 {name=r1011}
C {devices/bus_connect_nolab.sym} 3600 -1440 2 0 {name=r1012}
C {devices/bus_connect_nolab.sym} 3600 -1500 2 0 {name=r1013}
C {devices/bus_connect_nolab.sym} 3600 -1480 2 0 {name=r1014}
C {devices/lab_wire.sym} 3650 -1200 0 0 {name=l361 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 3650 -1220 0 0 {name=l362 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 3650 -1240 0 0 {name=l363 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -1240 0 0 {name=l364 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 3650 -1260 0 0 {name=l365 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 3650 -1280 0 0 {name=l366 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 3650 -1300 0 0 {name=l367 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 3650 -1320 0 0 {name=l368 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 3650 -1340 0 0 {name=l369 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 3650 -1360 0 0 {name=l370 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 3650 -1380 0 0 {name=l371 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 3650 -1420 0 0 {name=l372 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 3650 -1400 0 0 {name=l373 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 3650 -1440 0 0 {name=l374 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 3650 -1460 0 0 {name=l375 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 3650 -1480 0 0 {name=l376 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 3650 -1500 0 0 {name=l377 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 3590 -1150 3 0 {name=l378 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 4220 -1200 2 1 {name=r1015}
C {devices/bus_connect_nolab.sym} 4220 -1220 2 1 {name=r1016}
C {devices/bus_connect_nolab.sym} 4220 -1240 2 1 {name=r1017}
C {devices/bus_connect_nolab.sym} 4220 -1260 2 1 {name=r1018}
C {devices/bus_connect_nolab.sym} 4220 -1280 2 1 {name=r1019}
C {devices/bus_connect_nolab.sym} 4220 -1300 2 1 {name=r1020}
C {devices/bus_connect_nolab.sym} 4220 -1320 2 1 {name=r1021}
C {devices/bus_connect_nolab.sym} 4220 -1340 2 1 {name=r1022}
C {devices/bus_connect_nolab.sym} 4220 -1360 2 1 {name=r1023}
C {devices/bus_connect_nolab.sym} 4220 -1380 2 1 {name=r1024}
C {devices/bus_connect_nolab.sym} 4220 -1400 2 1 {name=r1025}
C {devices/bus_connect_nolab.sym} 4220 -1420 2 1 {name=r1026}
C {devices/bus_connect_nolab.sym} 4220 -1440 2 1 {name=r1027}
C {devices/bus_connect_nolab.sym} 4220 -1460 2 1 {name=r1028}
C {devices/bus_connect_nolab.sym} 4220 -1480 2 1 {name=r1029}
C {devices/bus_connect_nolab.sym} 4220 -1500 2 1 {name=r1030}
C {devices/lab_pin.sym} 4230 -1150 3 0 {name=l379 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 4170 -1500 0 1 {name=l380 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 4170 -1480 0 1 {name=l400 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 4170 -1460 0 1 {name=l401 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 4170 -1440 0 1 {name=l402 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 4170 -1420 0 1 {name=l403 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 4170 -1400 0 1 {name=l404 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 4170 -1380 0 1 {name=l405 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 4170 -1360 0 1 {name=l406 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 4170 -1340 0 1 {name=l407 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 4170 -1320 0 1 {name=l408 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 4170 -1300 0 1 {name=l409 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 4170 -1280 0 1 {name=l410 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 4170 -1260 0 1 {name=l411 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 4170 -1240 0 1 {name=l412 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 4170 -1220 0 1 {name=l413 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 4170 -1200 0 1 {name=l414 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3750 -520 2 0 {name=r1031}
C {devices/bus_connect_nolab.sym} 3750 -540 2 0 {name=r1032}
C {devices/bus_connect_nolab.sym} 3750 -560 2 0 {name=r1033}
C {devices/bus_connect_nolab.sym} 3750 -580 2 0 {name=r1034}
C {devices/bus_connect_nolab.sym} 3750 -600 2 0 {name=r1035}
C {devices/bus_connect_nolab.sym} 3750 -620 2 0 {name=r1036}
C {devices/bus_connect_nolab.sym} 3750 -640 2 0 {name=r1037}
C {devices/bus_connect_nolab.sym} 3750 -660 2 0 {name=r1038}
C {devices/bus_connect_nolab.sym} 3750 -680 2 0 {name=r1039}
C {devices/bus_connect_nolab.sym} 3750 -700 2 0 {name=r1040}
C {devices/bus_connect_nolab.sym} 3750 -720 2 0 {name=r1041}
C {devices/bus_connect_nolab.sym} 3750 -740 2 0 {name=r1042}
C {devices/bus_connect_nolab.sym} 3750 -760 2 0 {name=r1043}
C {devices/bus_connect_nolab.sym} 3750 -780 2 0 {name=r1044}
C {devices/bus_connect_nolab.sym} 3750 -800 2 0 {name=r1045}
C {devices/bus_connect_nolab.sym} 3750 -820 2 0 {name=r1046}
C {devices/lab_pin.sym} 3740 -480 3 0 {name=l415 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 4170 -520 2 1 {name=r1047}
C {devices/bus_connect_nolab.sym} 4170 -540 2 1 {name=r1048}
C {devices/bus_connect_nolab.sym} 4170 -560 2 1 {name=r1049}
C {devices/bus_connect_nolab.sym} 4170 -580 2 1 {name=r1050}
C {devices/bus_connect_nolab.sym} 4170 -600 2 1 {name=r1051}
C {devices/bus_connect_nolab.sym} 4170 -620 2 1 {name=r1052}
C {devices/bus_connect_nolab.sym} 4170 -640 2 1 {name=r1053}
C {devices/bus_connect_nolab.sym} 4170 -660 2 1 {name=r1054}
C {devices/bus_connect_nolab.sym} 4170 -680 2 1 {name=r1055}
C {devices/bus_connect_nolab.sym} 4170 -700 2 1 {name=r1056}
C {devices/bus_connect_nolab.sym} 4170 -720 2 1 {name=r1057}
C {devices/bus_connect_nolab.sym} 4170 -740 2 1 {name=r1058}
C {devices/bus_connect_nolab.sym} 4170 -760 2 1 {name=r1059}
C {devices/bus_connect_nolab.sym} 4170 -780 2 1 {name=r1060}
C {devices/bus_connect_nolab.sym} 4170 -800 2 1 {name=r1061}
C {devices/bus_connect_nolab.sym} 4170 -820 2 1 {name=r1062}
C {devices/lab_pin.sym} 4180 -480 1 1 {name=l416 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 3790 -540 0 0 {name=l417 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 3790 -560 0 0 {name=l418 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 3790 -580 0 0 {name=l419 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 3790 -600 0 0 {name=l420 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 3790 -620 0 0 {name=l421 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 3790 -640 0 0 {name=l422 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 3790 -660 0 0 {name=l423 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 3790 -680 0 0 {name=l424 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 3790 -700 0 0 {name=l425 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 3790 -740 0 0 {name=l426 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 3790 -720 0 0 {name=l427 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 3790 -760 0 0 {name=l428 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 3790 -780 0 0 {name=l429 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 3790 -800 0 0 {name=l430 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 3790 -820 0 0 {name=l431 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 3790 -520 0 0 {name=l432 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 4130 -540 0 1 {name=l433 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 4130 -560 0 1 {name=l434 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 4130 -580 0 1 {name=l435 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 4130 -600 0 1 {name=l436 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 4130 -620 0 1 {name=l437 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 4130 -640 0 1 {name=l438 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 4130 -660 0 1 {name=l439 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 4130 -680 0 1 {name=l440 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 4130 -700 0 1 {name=l441 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 4130 -740 0 1 {name=l442 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 4130 -720 0 1 {name=l443 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 4130 -760 0 1 {name=l444 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 4130 -780 0 1 {name=l445 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 4130 -800 0 1 {name=l446 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 4130 -820 0 1 {name=l447 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 4130 -520 0 1 {name=l448 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 2340 -1690 2 1 {name=l449 lab=Vrminus}
C {devices/lab_pin.sym} 2340 -1710 0 0 {name=l450 lab=SAMPLE}
C {devices/lab_pin.sym} 2340 -1810 0 0 {name=l451 lab=row0_sel}
C {devices/lab_pin.sym} 2340 -1790 0 0 {name=l452 lab=col3_sel}
C {devices/lab_pin.sym} 2340 -1730 0 0 {name=l453 lab=Vgpr}
C {devices/lab_pin.sym} 2340 -1770 0 0 {name=l454 lab=Vgnr}
C {devices/lab_pin.sym} 2340 -1750 0 0 {name=l455 lab=WR}
C {devices/lab_pin.sym} 2340 -1670 2 1 {name=l456 lab=Vrplus}
C {devices/lab_pin.sym} 2340 -1610 0 0 {name=l457 lab=Vref}
C {devices/lab_pin.sym} 2340 -1570 0 0 {name=l458 lab=Vcplus}
C {devices/lab_pin.sym} 2340 -1590 0 0 {name=l459 lab=Vcminus}
C {devices/lab_pin.sym} 2340 -1630 2 1 {name=l460 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 2340 -1650 2 1 {name=l461 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3040 -1680 2 1 {name=l462 lab=Vrminus}
C {devices/lab_pin.sym} 3040 -1700 0 0 {name=l463 lab=SAMPLE}
C {devices/lab_pin.sym} 3040 -1800 0 0 {name=l464 lab=row0_sel}
C {devices/lab_pin.sym} 3040 -1780 0 0 {name=l465 lab=col4_sel}
C {devices/lab_pin.sym} 3040 -1720 0 0 {name=l466 lab=Vgpr}
C {devices/lab_pin.sym} 3040 -1760 0 0 {name=l467 lab=Vgnr}
C {devices/lab_pin.sym} 3040 -1740 0 0 {name=l468 lab=WR}
C {devices/lab_pin.sym} 3040 -1660 2 1 {name=l469 lab=Vrplus}
C {devices/lab_pin.sym} 3040 -1600 0 0 {name=l470 lab=Vref}
C {devices/lab_pin.sym} 3040 -1560 0 0 {name=l471 lab=Vcplus}
C {devices/lab_pin.sym} 3040 -1580 0 0 {name=l472 lab=Vcminus}
C {devices/lab_pin.sym} 3040 -1620 2 1 {name=l473 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3040 -1640 2 1 {name=l474 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 3750 -1680 2 1 {name=l475 lab=Vrminus}
C {devices/lab_pin.sym} 3750 -1700 0 0 {name=l3975 lab=SAMPLE}
C {devices/lab_pin.sym} 3750 -1800 0 0 {name=l3976 lab=row0_sel}
C {devices/lab_pin.sym} 3750 -1780 0 0 {name=l3977 lab=col5_sel}
C {devices/lab_pin.sym} 3750 -1720 0 0 {name=l4146 lab=Vgpr}
C {devices/lab_pin.sym} 3750 -1760 0 0 {name=l4147 lab=Vgnr}
C {devices/lab_pin.sym} 3750 -1740 0 0 {name=l4148 lab=WR}
C {devices/lab_pin.sym} 3750 -1660 2 1 {name=l4149 lab=Vrplus}
C {devices/lab_pin.sym} 3750 -1600 0 0 {name=l4150 lab=Vref}
C {devices/lab_pin.sym} 3750 -1560 0 0 {name=l4151 lab=Vcplus}
C {devices/lab_pin.sym} 3750 -1580 0 0 {name=l4152 lab=Vcminus}
C {devices/lab_pin.sym} 3750 -1620 2 1 {name=l4153 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 3750 -1640 2 1 {name=l4154 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 190 -3940 0 0 {name=l389 lab=row1_sel}
C {devices/lab_pin.sym} 190 -3920 0 0 {name=l390 lab=col0_sel}
C {devices/lab_pin.sym} 610 -3940 2 0 {name=l1683 lab=latch_high0}
C {devices/lab_pin.sym} 2030 -3930 2 0 {name=l1685 lab=latch_high2}
C {devices/lab_pin.sym} 910 -3820 2 1 {name=l391 lab=Vrminus}
C {devices/lab_pin.sym} 910 -3840 0 0 {name=l392 lab=SAMPLE}
C {devices/lab_pin.sym} 2760 -3900 2 0 {name=l393 lab=vdda1}
C {devices/lab_pin.sym} 2760 -3920 2 0 {name=l395 lab=vccd1}
C {devices/lab_pin.sym} 2760 -3940 2 0 {name=l1686 lab=latch_high3}
C {devices/lab_pin.sym} 3460 -3890 2 0 {name=l396 lab=vdda1}
C {devices/lab_pin.sym} 3460 -3910 2 0 {name=l398 lab=vccd1}
C {devices/lab_pin.sym} 3460 -3930 2 0 {name=l1687 lab=latch_high4}
C {devices/lab_pin.sym} 4170 -3890 2 0 {name=l399 lab=vdda1}
C {devices/lab_pin.sym} 4170 -3910 2 0 {name=l477 lab=vccd1}
C {devices/lab_pin.sym} 4170 -3930 2 0 {name=l1688 lab=latch_high5}
C {devices/lab_wire.sym} 130 -3300 0 0 {name=l478 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 130 -3280 0 0 {name=l479 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 130 -3260 0 0 {name=l480 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 130 -3240 0 0 {name=l481 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 130 -3220 0 0 {name=l482 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 130 -3200 0 0 {name=l483 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 130 -3180 0 0 {name=l484 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 130 -3160 0 0 {name=l485 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 130 -3140 0 0 {name=l486 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 130 -3120 0 0 {name=l487 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 130 -3100 0 0 {name=l488 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 130 -3080 0 0 {name=l489 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 130 -3060 0 0 {name=l490 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 130 -3040 0 0 {name=l491 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 130 -3020 0 0 {name=l492 sig_type=std_logic lab=WL1}
C {devices/lab_wire.sym} 130 -3000 0 0 {name=l493 sig_type=std_logic lab=WL0}
C {devices/lab_pin.sym} 60 -2960 3 0 {name=l494 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 70 -3000 2 0 {name=r97}
C {devices/bus_connect_nolab.sym} 70 -3020 2 0 {name=r98}
C {devices/bus_connect_nolab.sym} 70 -3040 2 0 {name=r99}
C {devices/bus_connect_nolab.sym} 70 -3060 2 0 {name=r100}
C {devices/bus_connect_nolab.sym} 70 -3080 2 0 {name=r101}
C {devices/bus_connect_nolab.sym} 70 -3100 2 0 {name=r102}
C {devices/bus_connect_nolab.sym} 70 -3120 2 0 {name=r103}
C {devices/bus_connect_nolab.sym} 70 -3140 2 0 {name=r104}
C {devices/bus_connect_nolab.sym} 70 -3160 2 0 {name=r105}
C {devices/bus_connect_nolab.sym} 70 -3180 2 0 {name=r106}
C {devices/bus_connect_nolab.sym} 70 -3200 2 0 {name=r107}
C {devices/bus_connect_nolab.sym} 70 -3220 2 0 {name=r108}
C {devices/bus_connect_nolab.sym} 70 -3240 2 0 {name=r109}
C {devices/bus_connect_nolab.sym} 70 -3260 2 0 {name=r110}
C {devices/bus_connect_nolab.sym} 70 -3280 2 0 {name=r111}
C {devices/bus_connect_nolab.sym} 70 -3300 2 0 {name=r112}
C {devices/lab_wire.sym} 850 -3300 0 0 {name=l495 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 850 -3280 0 0 {name=l496 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 850 -3260 0 0 {name=l497 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 850 -3240 0 0 {name=l498 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 850 -3220 0 0 {name=l499 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 850 -3200 0 0 {name=l500 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 850 -3180 0 0 {name=l501 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 850 -3160 0 0 {name=l502 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 850 -3140 0 0 {name=l503 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 850 -3120 0 0 {name=l504 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 850 -3100 0 0 {name=l505 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 850 -3080 0 0 {name=l506 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 850 -3060 0 0 {name=l507 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 850 -3040 0 0 {name=l508 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 850 -3020 0 0 {name=l509 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 780 -2960 3 0 {name=l510 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 790 -3000 2 0 {name=r113}
C {devices/bus_connect_nolab.sym} 790 -3020 2 0 {name=r114}
C {devices/bus_connect_nolab.sym} 790 -3040 2 0 {name=r115}
C {devices/bus_connect_nolab.sym} 790 -3060 2 0 {name=r116}
C {devices/bus_connect_nolab.sym} 790 -3080 2 0 {name=r117}
C {devices/bus_connect_nolab.sym} 790 -3100 2 0 {name=r118}
C {devices/bus_connect_nolab.sym} 790 -3120 2 0 {name=r119}
C {devices/bus_connect_nolab.sym} 790 -3140 2 0 {name=r120}
C {devices/bus_connect_nolab.sym} 790 -3160 2 0 {name=r121}
C {devices/bus_connect_nolab.sym} 790 -3180 2 0 {name=r122}
C {devices/bus_connect_nolab.sym} 790 -3200 2 0 {name=r123}
C {devices/bus_connect_nolab.sym} 790 -3220 2 0 {name=r124}
C {devices/bus_connect_nolab.sym} 790 -3240 2 0 {name=r125}
C {devices/bus_connect_nolab.sym} 790 -3260 2 0 {name=r126}
C {devices/bus_connect_nolab.sym} 790 -3280 2 0 {name=r127}
C {devices/bus_connect_nolab.sym} 790 -3300 2 0 {name=r128}
C {devices/lab_wire.sym} 850 -3000 0 0 {name=l511 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 1550 -3290 0 0 {name=l512 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 1550 -3270 0 0 {name=l513 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 1550 -3250 0 0 {name=l514 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 1550 -3230 0 0 {name=l515 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 1550 -3210 0 0 {name=l516 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 1550 -3190 0 0 {name=l517 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 1550 -3170 0 0 {name=l518 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 1550 -3150 0 0 {name=l519 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 1550 -3130 0 0 {name=l520 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 1550 -3110 0 0 {name=l521 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 1550 -3090 0 0 {name=l522 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 1550 -3070 0 0 {name=l523 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 1550 -3050 0 0 {name=l524 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 1550 -3030 0 0 {name=l525 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 1550 -3010 0 0 {name=l526 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 1480 -2950 0 0 {name=l527 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 1490 -2990 2 0 {name=r129}
C {devices/bus_connect_nolab.sym} 1490 -3010 2 0 {name=r130}
C {devices/bus_connect_nolab.sym} 1490 -3030 2 0 {name=r131}
C {devices/bus_connect_nolab.sym} 1490 -3050 2 0 {name=r132}
C {devices/bus_connect_nolab.sym} 1490 -3070 2 0 {name=r133}
C {devices/bus_connect_nolab.sym} 1490 -3090 2 0 {name=r134}
C {devices/bus_connect_nolab.sym} 1490 -3110 2 0 {name=r135}
C {devices/bus_connect_nolab.sym} 1490 -3130 2 0 {name=r136}
C {devices/bus_connect_nolab.sym} 1490 -3150 2 0 {name=r137}
C {devices/bus_connect_nolab.sym} 1490 -3170 2 0 {name=r138}
C {devices/bus_connect_nolab.sym} 1490 -3190 2 0 {name=r139}
C {devices/bus_connect_nolab.sym} 1490 -3210 2 0 {name=r140}
C {devices/bus_connect_nolab.sym} 1490 -3230 2 0 {name=r141}
C {devices/bus_connect_nolab.sym} 1490 -3250 2 0 {name=r142}
C {devices/bus_connect_nolab.sym} 1490 -3270 2 0 {name=r143}
C {devices/bus_connect_nolab.sym} 1490 -3290 2 0 {name=r144}
C {devices/lab_wire.sym} 1550 -2990 0 0 {name=l528 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2280 -3300 0 0 {name=l529 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2280 -3280 0 0 {name=l530 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2280 -3260 0 0 {name=l531 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2280 -3240 0 0 {name=l532 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2280 -3220 0 0 {name=l533 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2280 -3200 0 0 {name=l534 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2280 -3180 0 0 {name=l535 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2280 -3160 0 0 {name=l536 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2280 -3140 0 0 {name=l537 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2280 -3120 0 0 {name=l538 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2280 -3100 0 0 {name=l539 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2280 -3080 0 0 {name=l540 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2280 -3060 0 0 {name=l541 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2280 -3040 0 0 {name=l542 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2280 -3020 0 0 {name=l543 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2210 -2960 0 0 {name=l544 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2220 -3000 2 0 {name=r145}
C {devices/bus_connect_nolab.sym} 2220 -3020 2 0 {name=r146}
C {devices/bus_connect_nolab.sym} 2220 -3040 2 0 {name=r147}
C {devices/bus_connect_nolab.sym} 2220 -3060 2 0 {name=r148}
C {devices/bus_connect_nolab.sym} 2220 -3080 2 0 {name=r149}
C {devices/bus_connect_nolab.sym} 2220 -3100 2 0 {name=r150}
C {devices/bus_connect_nolab.sym} 2220 -3120 2 0 {name=r151}
C {devices/bus_connect_nolab.sym} 2220 -3140 2 0 {name=r152}
C {devices/bus_connect_nolab.sym} 2220 -3160 2 0 {name=r153}
C {devices/bus_connect_nolab.sym} 2220 -3180 2 0 {name=r154}
C {devices/bus_connect_nolab.sym} 2220 -3200 2 0 {name=r155}
C {devices/bus_connect_nolab.sym} 2220 -3220 2 0 {name=r156}
C {devices/bus_connect_nolab.sym} 2220 -3240 2 0 {name=r157}
C {devices/bus_connect_nolab.sym} 2220 -3260 2 0 {name=r158}
C {devices/bus_connect_nolab.sym} 2220 -3280 2 0 {name=r159}
C {devices/bus_connect_nolab.sym} 2220 -3300 2 0 {name=r160}
C {devices/lab_wire.sym} 2280 -3000 0 0 {name=l545 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 2980 -3290 0 0 {name=l546 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 2980 -3270 0 0 {name=l547 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 2980 -3250 0 0 {name=l548 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 2980 -3230 0 0 {name=l549 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 2980 -3210 0 0 {name=l550 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 2980 -3190 0 0 {name=l551 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 2980 -3170 0 0 {name=l552 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 2980 -3150 0 0 {name=l553 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 2980 -3130 0 0 {name=l554 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 2980 -3110 0 0 {name=l555 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 2980 -3090 0 0 {name=l556 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 2980 -3070 0 0 {name=l557 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 2980 -3050 0 0 {name=l558 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 2980 -3030 0 0 {name=l559 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 2980 -3010 0 0 {name=l560 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 2910 -2950 0 0 {name=l561 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 2920 -2990 2 0 {name=r161}
C {devices/bus_connect_nolab.sym} 2920 -3010 2 0 {name=r162}
C {devices/bus_connect_nolab.sym} 2920 -3030 2 0 {name=r163}
C {devices/bus_connect_nolab.sym} 2920 -3050 2 0 {name=r164}
C {devices/bus_connect_nolab.sym} 2920 -3070 2 0 {name=r165}
C {devices/bus_connect_nolab.sym} 2920 -3090 2 0 {name=r166}
C {devices/bus_connect_nolab.sym} 2920 -3110 2 0 {name=r167}
C {devices/bus_connect_nolab.sym} 2920 -3130 2 0 {name=r168}
C {devices/bus_connect_nolab.sym} 2920 -3150 2 0 {name=r169}
C {devices/bus_connect_nolab.sym} 2920 -3170 2 0 {name=r170}
C {devices/bus_connect_nolab.sym} 2920 -3190 2 0 {name=r171}
C {devices/bus_connect_nolab.sym} 2920 -3210 2 0 {name=r172}
C {devices/bus_connect_nolab.sym} 2920 -3230 2 0 {name=r173}
C {devices/bus_connect_nolab.sym} 2920 -3250 2 0 {name=r174}
C {devices/bus_connect_nolab.sym} 2920 -3270 2 0 {name=r175}
C {devices/bus_connect_nolab.sym} 2920 -3290 2 0 {name=r176}
C {devices/lab_wire.sym} 2980 -2990 0 0 {name=l562 sig_type=std_logic lab=WL0}
C {devices/lab_wire.sym} 3690 -3290 0 0 {name=l563 sig_type=std_logic lab=WL15}
C {devices/lab_wire.sym} 3690 -3270 0 0 {name=l564 sig_type=std_logic lab=WL14}
C {devices/lab_wire.sym} 3690 -3250 0 0 {name=l565 sig_type=std_logic lab=WL13}
C {devices/lab_wire.sym} 3690 -3230 0 0 {name=l566 sig_type=std_logic lab=WL12}
C {devices/lab_wire.sym} 3690 -3210 0 0 {name=l567 sig_type=std_logic lab=WL11}
C {devices/lab_wire.sym} 3690 -3190 0 0 {name=l568 sig_type=std_logic lab=WL10}
C {devices/lab_wire.sym} 3690 -3170 0 0 {name=l569 sig_type=std_logic lab=WL9}
C {devices/lab_wire.sym} 3690 -3150 0 0 {name=l570 sig_type=std_logic lab=WL8}
C {devices/lab_wire.sym} 3690 -3130 0 0 {name=l571 sig_type=std_logic lab=WL7}
C {devices/lab_wire.sym} 3690 -3110 0 0 {name=l572 sig_type=std_logic lab=WL6}
C {devices/lab_wire.sym} 3690 -3090 0 0 {name=l573 sig_type=std_logic lab=WL5}
C {devices/lab_wire.sym} 3690 -3070 0 0 {name=l574 sig_type=std_logic lab=WL4}
C {devices/lab_wire.sym} 3690 -3050 0 0 {name=l575 sig_type=std_logic lab=WL3}
C {devices/lab_wire.sym} 3690 -3030 0 0 {name=l576 sig_type=std_logic lab=WL2}
C {devices/lab_wire.sym} 3690 -3010 0 0 {name=l577 sig_type=std_logic lab=WL1}
C {devices/lab_pin.sym} 3620 -2950 0 0 {name=l578 sig_type=std_logic lab=WL[0..15]}
C {devices/bus_connect_nolab.sym} 3630 -2990 2 0 {name=r177}
C {devices/bus_connect_nolab.sym} 3630 -3010 2 0 {name=r178}
C {devices/bus_connect_nolab.sym} 3630 -3030 2 0 {name=r179}
C {devices/bus_connect_nolab.sym} 3630 -3050 2 0 {name=r180}
C {devices/bus_connect_nolab.sym} 3630 -3070 2 0 {name=r181}
C {devices/bus_connect_nolab.sym} 3630 -3090 2 0 {name=r182}
C {devices/bus_connect_nolab.sym} 3630 -3110 2 0 {name=r183}
C {devices/bus_connect_nolab.sym} 3630 -3130 2 0 {name=r184}
C {devices/bus_connect_nolab.sym} 3630 -3150 2 0 {name=r185}
C {devices/bus_connect_nolab.sym} 3630 -3170 2 0 {name=r186}
C {devices/bus_connect_nolab.sym} 3630 -3190 2 0 {name=r187}
C {devices/bus_connect_nolab.sym} 3630 -3210 2 0 {name=r188}
C {devices/bus_connect_nolab.sym} 3630 -3230 2 0 {name=r189}
C {devices/bus_connect_nolab.sym} 3630 -3250 2 0 {name=r190}
C {devices/bus_connect_nolab.sym} 3630 -3270 2 0 {name=r191}
C {devices/bus_connect_nolab.sym} 3630 -3290 2 0 {name=r192}
C {devices/lab_wire.sym} 3690 -2990 0 0 {name=l579 sig_type=std_logic lab=WL0}
C {devices/bus_connect_nolab.sym} 40 -3340 2 0 {name=r1063}
C {devices/bus_connect_nolab.sym} 40 -3360 2 0 {name=r1064}
C {devices/bus_connect_nolab.sym} 40 -3380 2 0 {name=r1065}
C {devices/bus_connect_nolab.sym} 40 -3400 2 0 {name=r1066}
C {devices/bus_connect_nolab.sym} 40 -3420 2 0 {name=r1067}
C {devices/bus_connect_nolab.sym} 40 -3440 2 0 {name=r1068}
C {devices/bus_connect_nolab.sym} 40 -3460 2 0 {name=r1069}
C {devices/bus_connect_nolab.sym} 40 -3480 2 0 {name=r1070}
C {devices/bus_connect_nolab.sym} 40 -3500 2 0 {name=r1071}
C {devices/bus_connect_nolab.sym} 40 -3520 2 0 {name=r1072}
C {devices/bus_connect_nolab.sym} 40 -3560 2 0 {name=r1073}
C {devices/bus_connect_nolab.sym} 40 -3540 2 0 {name=r1074}
C {devices/bus_connect_nolab.sym} 40 -3600 2 0 {name=r1075}
C {devices/bus_connect_nolab.sym} 40 -3580 2 0 {name=r1076}
C {devices/bus_connect_nolab.sym} 40 -3640 2 0 {name=r1077}
C {devices/bus_connect_nolab.sym} 40 -3620 2 0 {name=r1078}
C {devices/lab_wire.sym} 90 -3340 0 0 {name=l580 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 90 -3360 0 0 {name=l581 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 90 -3380 0 0 {name=l582 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -3380 0 0 {name=l583 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 90 -3400 0 0 {name=l584 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 90 -3420 0 0 {name=l585 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 90 -3440 0 0 {name=l586 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 90 -3460 0 0 {name=l587 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 90 -3480 0 0 {name=l588 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 90 -3500 0 0 {name=l589 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 90 -3520 0 0 {name=l590 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 90 -3560 0 0 {name=l591 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 90 -3540 0 0 {name=l592 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 90 -3580 0 0 {name=l593 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 90 -3600 0 0 {name=l594 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 90 -3620 0 0 {name=l595 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 90 -3640 0 0 {name=l596 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 30 -3290 3 0 {name=l597 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 660 -3340 2 1 {name=r1079}
C {devices/bus_connect_nolab.sym} 660 -3360 2 1 {name=r1080}
C {devices/bus_connect_nolab.sym} 660 -3380 2 1 {name=r1081}
C {devices/bus_connect_nolab.sym} 660 -3400 2 1 {name=r1082}
C {devices/bus_connect_nolab.sym} 660 -3420 2 1 {name=r1083}
C {devices/bus_connect_nolab.sym} 660 -3440 2 1 {name=r1084}
C {devices/bus_connect_nolab.sym} 660 -3460 2 1 {name=r1085}
C {devices/bus_connect_nolab.sym} 660 -3480 2 1 {name=r1086}
C {devices/bus_connect_nolab.sym} 660 -3500 2 1 {name=r1087}
C {devices/bus_connect_nolab.sym} 660 -3520 2 1 {name=r1088}
C {devices/bus_connect_nolab.sym} 660 -3540 2 1 {name=r1089}
C {devices/bus_connect_nolab.sym} 660 -3560 2 1 {name=r1090}
C {devices/bus_connect_nolab.sym} 660 -3580 2 1 {name=r1091}
C {devices/bus_connect_nolab.sym} 660 -3600 2 1 {name=r1092}
C {devices/bus_connect_nolab.sym} 660 -3620 2 1 {name=r1093}
C {devices/bus_connect_nolab.sym} 660 -3640 2 1 {name=r1094}
C {devices/lab_pin.sym} 670 -3290 3 0 {name=l598 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 610 -3640 0 1 {name=l599 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 610 -3620 0 1 {name=l600 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 610 -3600 0 1 {name=l601 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 610 -3580 0 1 {name=l602 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 610 -3560 0 1 {name=l603 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 610 -3540 0 1 {name=l604 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 610 -3520 0 1 {name=l605 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 610 -3500 0 1 {name=l606 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 610 -3480 0 1 {name=l607 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 610 -3460 0 1 {name=l608 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 610 -3440 0 1 {name=l609 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 610 -3420 0 1 {name=l610 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 610 -3400 0 1 {name=l611 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 610 -3380 0 1 {name=l612 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 610 -3360 0 1 {name=l613 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 610 -3340 0 1 {name=l614 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 190 -2660 2 0 {name=r1095}
C {devices/bus_connect_nolab.sym} 190 -2680 2 0 {name=r1096}
C {devices/bus_connect_nolab.sym} 190 -2700 2 0 {name=r1097}
C {devices/bus_connect_nolab.sym} 190 -2720 2 0 {name=r1098}
C {devices/bus_connect_nolab.sym} 190 -2740 2 0 {name=r1099}
C {devices/bus_connect_nolab.sym} 190 -2760 2 0 {name=r1100}
C {devices/bus_connect_nolab.sym} 190 -2780 2 0 {name=r1101}
C {devices/bus_connect_nolab.sym} 190 -2800 2 0 {name=r1102}
C {devices/bus_connect_nolab.sym} 190 -2820 2 0 {name=r1103}
C {devices/bus_connect_nolab.sym} 190 -2840 2 0 {name=r1104}
C {devices/bus_connect_nolab.sym} 190 -2860 2 0 {name=r1105}
C {devices/bus_connect_nolab.sym} 190 -2880 2 0 {name=r1106}
C {devices/bus_connect_nolab.sym} 190 -2900 2 0 {name=r1107}
C {devices/bus_connect_nolab.sym} 190 -2920 2 0 {name=r1108}
C {devices/bus_connect_nolab.sym} 190 -2940 2 0 {name=r1109}
C {devices/bus_connect_nolab.sym} 190 -2960 2 0 {name=r1110}
C {devices/lab_pin.sym} 180 -2620 3 0 {name=l615 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 610 -2660 2 1 {name=r1111}
C {devices/bus_connect_nolab.sym} 610 -2680 2 1 {name=r1112}
C {devices/bus_connect_nolab.sym} 610 -2700 2 1 {name=r1113}
C {devices/bus_connect_nolab.sym} 610 -2720 2 1 {name=r1114}
C {devices/bus_connect_nolab.sym} 610 -2740 2 1 {name=r1115}
C {devices/bus_connect_nolab.sym} 610 -2760 2 1 {name=r1116}
C {devices/bus_connect_nolab.sym} 610 -2780 2 1 {name=r1117}
C {devices/bus_connect_nolab.sym} 610 -2800 2 1 {name=r1118}
C {devices/bus_connect_nolab.sym} 610 -2820 2 1 {name=r1119}
C {devices/bus_connect_nolab.sym} 610 -2840 2 1 {name=r1120}
C {devices/bus_connect_nolab.sym} 610 -2860 2 1 {name=r1121}
C {devices/bus_connect_nolab.sym} 610 -2880 2 1 {name=r1122}
C {devices/bus_connect_nolab.sym} 610 -2900 2 1 {name=r1123}
C {devices/bus_connect_nolab.sym} 610 -2920 2 1 {name=r1124}
C {devices/bus_connect_nolab.sym} 610 -2940 2 1 {name=r1125}
C {devices/bus_connect_nolab.sym} 610 -2960 2 1 {name=r1126}
C {devices/lab_pin.sym} 620 -2620 1 1 {name=l616 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 230 -2680 0 0 {name=l617 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 230 -2700 0 0 {name=l618 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 230 -2720 0 0 {name=l619 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 230 -2740 0 0 {name=l620 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 230 -2760 0 0 {name=l621 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 230 -2780 0 0 {name=l622 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 230 -2800 0 0 {name=l623 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 230 -2820 0 0 {name=l624 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 230 -2840 0 0 {name=l625 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 230 -2880 0 0 {name=l626 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 230 -2860 0 0 {name=l627 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 230 -2900 0 0 {name=l628 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 230 -2920 0 0 {name=l629 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 230 -2940 0 0 {name=l630 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 230 -2960 0 0 {name=l631 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 230 -2660 0 0 {name=l632 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 570 -2680 0 1 {name=l633 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 570 -2700 0 1 {name=l634 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 570 -2720 0 1 {name=l635 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 570 -2740 0 1 {name=l636 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 570 -2760 0 1 {name=l637 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 570 -2780 0 1 {name=l638 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 570 -2800 0 1 {name=l639 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 570 -2820 0 1 {name=l640 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 570 -2840 0 1 {name=l641 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 570 -2880 0 1 {name=l642 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 570 -2860 0 1 {name=l643 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 570 -2900 0 1 {name=l644 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 570 -2920 0 1 {name=l645 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 570 -2940 0 1 {name=l646 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 570 -2960 0 1 {name=l647 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 570 -2660 0 1 {name=l648 sig_type=std_logic lab=cB0}
C {devices/lab_pin.sym} 910 -3940 0 0 {name=l649 lab=row1_sel}
C {devices/lab_pin.sym} 910 -3920 0 0 {name=l650 lab=col1_sel}
C {devices/lab_pin.sym} 1330 -3940 2 0 {name=l1684 lab=latch_high1}
C {devices/bus_connect_nolab.sym} 760 -3340 2 0 {name=r1127}
C {devices/bus_connect_nolab.sym} 760 -3360 2 0 {name=r1128}
C {devices/bus_connect_nolab.sym} 760 -3380 2 0 {name=r1129}
C {devices/bus_connect_nolab.sym} 760 -3400 2 0 {name=r1130}
C {devices/bus_connect_nolab.sym} 760 -3420 2 0 {name=r1131}
C {devices/bus_connect_nolab.sym} 760 -3440 2 0 {name=r1132}
C {devices/bus_connect_nolab.sym} 760 -3460 2 0 {name=r1133}
C {devices/bus_connect_nolab.sym} 760 -3480 2 0 {name=r1134}
C {devices/bus_connect_nolab.sym} 760 -3500 2 0 {name=r1135}
C {devices/bus_connect_nolab.sym} 760 -3520 2 0 {name=r1136}
C {devices/bus_connect_nolab.sym} 760 -3560 2 0 {name=r1137}
C {devices/bus_connect_nolab.sym} 760 -3540 2 0 {name=r1138}
C {devices/bus_connect_nolab.sym} 760 -3600 2 0 {name=r1139}
C {devices/bus_connect_nolab.sym} 760 -3580 2 0 {name=r1140}
C {devices/bus_connect_nolab.sym} 760 -3640 2 0 {name=r1141}
C {devices/bus_connect_nolab.sym} 760 -3620 2 0 {name=r1142}
C {devices/lab_wire.sym} 810 -3340 0 0 {name=l651 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 810 -3360 0 0 {name=l652 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 810 -3380 0 0 {name=l653 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -3380 0 0 {name=l654 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 810 -3400 0 0 {name=l655 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 810 -3420 0 0 {name=l656 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 810 -3440 0 0 {name=l657 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 810 -3460 0 0 {name=l658 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 810 -3480 0 0 {name=l659 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 810 -3500 0 0 {name=l660 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 810 -3520 0 0 {name=l661 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 810 -3560 0 0 {name=l662 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 810 -3540 0 0 {name=l663 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 810 -3580 0 0 {name=l664 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 810 -3600 0 0 {name=l665 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 810 -3620 0 0 {name=l666 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 810 -3640 0 0 {name=l667 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 750 -3290 3 0 {name=l668 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 1380 -3340 2 1 {name=r1143}
C {devices/bus_connect_nolab.sym} 1380 -3360 2 1 {name=r1144}
C {devices/bus_connect_nolab.sym} 1380 -3380 2 1 {name=r1145}
C {devices/bus_connect_nolab.sym} 1380 -3400 2 1 {name=r1146}
C {devices/bus_connect_nolab.sym} 1380 -3420 2 1 {name=r1147}
C {devices/bus_connect_nolab.sym} 1380 -3440 2 1 {name=r1148}
C {devices/bus_connect_nolab.sym} 1380 -3460 2 1 {name=r1149}
C {devices/bus_connect_nolab.sym} 1380 -3480 2 1 {name=r1150}
C {devices/bus_connect_nolab.sym} 1380 -3500 2 1 {name=r1151}
C {devices/bus_connect_nolab.sym} 1380 -3520 2 1 {name=r1152}
C {devices/bus_connect_nolab.sym} 1380 -3540 2 1 {name=r1153}
C {devices/bus_connect_nolab.sym} 1380 -3560 2 1 {name=r1154}
C {devices/bus_connect_nolab.sym} 1380 -3580 2 1 {name=r1155}
C {devices/bus_connect_nolab.sym} 1380 -3600 2 1 {name=r1156}
C {devices/bus_connect_nolab.sym} 1380 -3620 2 1 {name=r1157}
C {devices/bus_connect_nolab.sym} 1380 -3640 2 1 {name=r1158}
C {devices/lab_pin.sym} 1390 -3290 3 0 {name=l669 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 1330 -3640 0 1 {name=l670 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 1330 -3620 0 1 {name=l671 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 1330 -3600 0 1 {name=l672 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 1330 -3580 0 1 {name=l673 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 1330 -3560 0 1 {name=l674 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 1330 -3540 0 1 {name=l675 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 1330 -3520 0 1 {name=l676 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 1330 -3500 0 1 {name=l677 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 1330 -3480 0 1 {name=l678 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 1330 -3460 0 1 {name=l679 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 1330 -3440 0 1 {name=l680 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 1330 -3420 0 1 {name=l681 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 1330 -3400 0 1 {name=l682 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 1330 -3380 0 1 {name=l683 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 1330 -3360 0 1 {name=l684 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 1330 -3340 0 1 {name=l685 sig_type=std_logic lab=rB0}
C {devices/lab_pin.sym} 910 -3860 0 0 {name=l686 lab=Vgpr}
C {devices/lab_pin.sym} 910 -3900 0 0 {name=l687 lab=Vgnr}
C {devices/lab_pin.sym} 910 -3880 0 0 {name=l688 lab=WR}
C {devices/lab_pin.sym} 910 -3800 2 1 {name=l689 lab=Vrplus}
C {devices/lab_pin.sym} 910 -3740 0 0 {name=l690 lab=Vref}
C {devices/lab_pin.sym} 910 -3700 0 0 {name=l691 lab=Vcplus}
C {devices/lab_pin.sym} 910 -3720 0 0 {name=l692 lab=Vcminus}
C {devices/lab_pin.sym} 910 -3760 2 1 {name=l693 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 910 -3780 2 1 {name=l694 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 1330 -3900 2 0 {name=l695 lab=vdda1}
C {devices/lab_pin.sym} 1330 -3920 2 0 {name=l697 lab=vccd1}
C {devices/lab_pin.sym} 1610 -3810 2 1 {name=l698 lab=Vrminus}
C {devices/lab_pin.sym} 1610 -3830 0 0 {name=l699 lab=SAMPLE}
C {devices/lab_pin.sym} 1610 -3930 0 0 {name=l700 lab=row1_sel}
C {devices/lab_pin.sym} 1610 -3910 0 0 {name=l701 lab=col2_sel}
C {devices/lab_pin.sym} 1610 -3850 0 0 {name=l702 lab=Vgpr}
C {devices/lab_pin.sym} 1610 -3890 0 0 {name=l703 lab=Vgnr}
C {devices/lab_pin.sym} 1610 -3870 0 0 {name=l704 lab=WR}
C {devices/lab_pin.sym} 1610 -3790 2 1 {name=l705 lab=Vrplus}
C {devices/lab_pin.sym} 1610 -3730 0 0 {name=l706 lab=Vref}
C {devices/lab_pin.sym} 1610 -3690 0 0 {name=l707 lab=Vcplus}
C {devices/lab_pin.sym} 1610 -3710 0 0 {name=l708 lab=Vcminus}
C {devices/lab_pin.sym} 1610 -3750 2 1 {name=l709 sig_type=std_logic lab=Vref_comp}
C {devices/lab_pin.sym} 1610 -3770 2 1 {name=l710 sig_type=std_logic lab=RISC_CLK}
C {devices/lab_pin.sym} 2030 -3890 2 0 {name=l711 lab=vdda1}
C {devices/lab_pin.sym} 2030 -3910 2 0 {name=l713 lab=vccd1}
C {devices/bus_connect_nolab.sym} 1460 -3330 2 0 {name=r1159}
C {devices/bus_connect_nolab.sym} 1460 -3350 2 0 {name=r1160}
C {devices/bus_connect_nolab.sym} 1460 -3370 2 0 {name=r1161}
C {devices/bus_connect_nolab.sym} 1460 -3390 2 0 {name=r1162}
C {devices/bus_connect_nolab.sym} 1460 -3410 2 0 {name=r1163}
C {devices/bus_connect_nolab.sym} 1460 -3430 2 0 {name=r1164}
C {devices/bus_connect_nolab.sym} 1460 -3450 2 0 {name=r1165}
C {devices/bus_connect_nolab.sym} 1460 -3470 2 0 {name=r1166}
C {devices/bus_connect_nolab.sym} 1460 -3490 2 0 {name=r1167}
C {devices/bus_connect_nolab.sym} 1460 -3510 2 0 {name=r1168}
C {devices/bus_connect_nolab.sym} 1460 -3550 2 0 {name=r1169}
C {devices/bus_connect_nolab.sym} 1460 -3530 2 0 {name=r1170}
C {devices/bus_connect_nolab.sym} 1460 -3590 2 0 {name=r1171}
C {devices/bus_connect_nolab.sym} 1460 -3570 2 0 {name=r1172}
C {devices/bus_connect_nolab.sym} 1460 -3630 2 0 {name=r1173}
C {devices/bus_connect_nolab.sym} 1460 -3610 2 0 {name=r1174}
C {devices/lab_wire.sym} 1510 -3330 0 0 {name=l714 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 1510 -3350 0 0 {name=l715 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 1510 -3370 0 0 {name=l716 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -3370 0 0 {name=l717 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 1510 -3390 0 0 {name=l718 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 1510 -3410 0 0 {name=l719 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 1510 -3430 0 0 {name=l720 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 1510 -3450 0 0 {name=l721 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 1510 -3470 0 0 {name=l722 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 1510 -3490 0 0 {name=l723 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 1510 -3510 0 0 {name=l724 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 1510 -3550 0 0 {name=l725 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 1510 -3530 0 0 {name=l726 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 1510 -3570 0 0 {name=l727 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 1510 -3590 0 0 {name=l728 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 1510 -3610 0 0 {name=l729 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 1510 -3630 0 0 {name=l730 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 1450 -3280 3 0 {name=l731 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2080 -3330 2 1 {name=r1175}
C {devices/bus_connect_nolab.sym} 2080 -3350 2 1 {name=r1176}
C {devices/bus_connect_nolab.sym} 2080 -3370 2 1 {name=r1177}
C {devices/bus_connect_nolab.sym} 2080 -3390 2 1 {name=r1178}
C {devices/bus_connect_nolab.sym} 2080 -3410 2 1 {name=r1179}
C {devices/bus_connect_nolab.sym} 2080 -3430 2 1 {name=r1180}
C {devices/bus_connect_nolab.sym} 2080 -3450 2 1 {name=r1181}
C {devices/bus_connect_nolab.sym} 2080 -3470 2 1 {name=r1182}
C {devices/bus_connect_nolab.sym} 2080 -3490 2 1 {name=r1183}
C {devices/bus_connect_nolab.sym} 2080 -3510 2 1 {name=r1184}
C {devices/bus_connect_nolab.sym} 2080 -3530 2 1 {name=r1185}
C {devices/bus_connect_nolab.sym} 2080 -3550 2 1 {name=r1186}
C {devices/bus_connect_nolab.sym} 2080 -3570 2 1 {name=r1187}
C {devices/bus_connect_nolab.sym} 2080 -3590 2 1 {name=r1188}
C {devices/bus_connect_nolab.sym} 2080 -3610 2 1 {name=r1189}
C {devices/bus_connect_nolab.sym} 2080 -3630 2 1 {name=r1190}
C {devices/lab_pin.sym} 2090 -3280 3 0 {name=l732 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2030 -3630 0 1 {name=l733 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2030 -3610 0 1 {name=l734 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2030 -3590 0 1 {name=l735 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2030 -3570 0 1 {name=l736 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2030 -3550 0 1 {name=l737 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2030 -3530 0 1 {name=l738 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2030 -3510 0 1 {name=l739 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2030 -3490 0 1 {name=l740 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2030 -3470 0 1 {name=l741 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2030 -3450 0 1 {name=l742 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2030 -3430 0 1 {name=l743 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2030 -3410 0 1 {name=l744 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2030 -3390 0 1 {name=l745 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2030 -3370 0 1 {name=l746 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2030 -3350 0 1 {name=l747 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2030 -3330 0 1 {name=l748 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 910 -2660 2 0 {name=r1191}
C {devices/bus_connect_nolab.sym} 910 -2680 2 0 {name=r1192}
C {devices/bus_connect_nolab.sym} 910 -2700 2 0 {name=r1193}
C {devices/bus_connect_nolab.sym} 910 -2720 2 0 {name=r1194}
C {devices/bus_connect_nolab.sym} 910 -2740 2 0 {name=r1195}
C {devices/bus_connect_nolab.sym} 910 -2760 2 0 {name=r1196}
C {devices/bus_connect_nolab.sym} 910 -2780 2 0 {name=r1197}
C {devices/bus_connect_nolab.sym} 910 -2800 2 0 {name=r1198}
C {devices/bus_connect_nolab.sym} 910 -2820 2 0 {name=r1199}
C {devices/bus_connect_nolab.sym} 910 -2840 2 0 {name=r1200}
C {devices/bus_connect_nolab.sym} 910 -2860 2 0 {name=r1201}
C {devices/bus_connect_nolab.sym} 910 -2880 2 0 {name=r1202}
C {devices/bus_connect_nolab.sym} 910 -2900 2 0 {name=r1203}
C {devices/bus_connect_nolab.sym} 910 -2920 2 0 {name=r1204}
C {devices/bus_connect_nolab.sym} 910 -2940 2 0 {name=r1205}
C {devices/bus_connect_nolab.sym} 910 -2960 2 0 {name=r1206}
C {devices/lab_pin.sym} 900 -2620 3 0 {name=l749 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 1330 -2660 2 1 {name=r1207}
C {devices/bus_connect_nolab.sym} 1330 -2680 2 1 {name=r1208}
C {devices/bus_connect_nolab.sym} 1330 -2700 2 1 {name=r1209}
C {devices/bus_connect_nolab.sym} 1330 -2720 2 1 {name=r1210}
C {devices/bus_connect_nolab.sym} 1330 -2740 2 1 {name=r1211}
C {devices/bus_connect_nolab.sym} 1330 -2760 2 1 {name=r1212}
C {devices/bus_connect_nolab.sym} 1330 -2780 2 1 {name=r1213}
C {devices/bus_connect_nolab.sym} 1330 -2800 2 1 {name=r1214}
C {devices/bus_connect_nolab.sym} 1330 -2820 2 1 {name=r1215}
C {devices/bus_connect_nolab.sym} 1330 -2840 2 1 {name=r1216}
C {devices/bus_connect_nolab.sym} 1330 -2860 2 1 {name=r1217}
C {devices/bus_connect_nolab.sym} 1330 -2880 2 1 {name=r1218}
C {devices/bus_connect_nolab.sym} 1330 -2900 2 1 {name=r1219}
C {devices/bus_connect_nolab.sym} 1330 -2920 2 1 {name=r1220}
C {devices/bus_connect_nolab.sym} 1330 -2940 2 1 {name=r1221}
C {devices/bus_connect_nolab.sym} 1330 -2960 2 1 {name=r1222}
C {devices/lab_pin.sym} 1340 -2620 1 1 {name=l750 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 950 -2680 0 0 {name=l751 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 950 -2700 0 0 {name=l752 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 950 -2720 0 0 {name=l753 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 950 -2740 0 0 {name=l754 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 950 -2760 0 0 {name=l755 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 950 -2780 0 0 {name=l756 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 950 -2800 0 0 {name=l757 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 950 -2820 0 0 {name=l758 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 950 -2840 0 0 {name=l759 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 950 -2880 0 0 {name=l760 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 950 -2860 0 0 {name=l761 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 950 -2900 0 0 {name=l762 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 950 -2920 0 0 {name=l763 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 950 -2940 0 0 {name=l764 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 950 -2960 0 0 {name=l765 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 950 -2660 0 0 {name=l766 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1290 -2680 0 1 {name=l767 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1290 -2700 0 1 {name=l768 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1290 -2720 0 1 {name=l769 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1290 -2740 0 1 {name=l770 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1290 -2760 0 1 {name=l771 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1290 -2780 0 1 {name=l772 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1290 -2800 0 1 {name=l773 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1290 -2820 0 1 {name=l774 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1290 -2840 0 1 {name=l775 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1290 -2880 0 1 {name=l776 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1290 -2860 0 1 {name=l777 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1290 -2900 0 1 {name=l778 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1290 -2920 0 1 {name=l779 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1290 -2940 0 1 {name=l780 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1290 -2960 0 1 {name=l781 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1290 -2660 0 1 {name=l782 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 1610 -2650 2 0 {name=r1223}
C {devices/bus_connect_nolab.sym} 1610 -2670 2 0 {name=r1224}
C {devices/bus_connect_nolab.sym} 1610 -2690 2 0 {name=r1225}
C {devices/bus_connect_nolab.sym} 1610 -2710 2 0 {name=r1226}
C {devices/bus_connect_nolab.sym} 1610 -2730 2 0 {name=r1227}
C {devices/bus_connect_nolab.sym} 1610 -2750 2 0 {name=r1228}
C {devices/bus_connect_nolab.sym} 1610 -2770 2 0 {name=r1229}
C {devices/bus_connect_nolab.sym} 1610 -2790 2 0 {name=r1230}
C {devices/bus_connect_nolab.sym} 1610 -2810 2 0 {name=r1231}
C {devices/bus_connect_nolab.sym} 1610 -2830 2 0 {name=r1232}
C {devices/bus_connect_nolab.sym} 1610 -2850 2 0 {name=r1233}
C {devices/bus_connect_nolab.sym} 1610 -2870 2 0 {name=r1234}
C {devices/bus_connect_nolab.sym} 1610 -2890 2 0 {name=r1235}
C {devices/bus_connect_nolab.sym} 1610 -2910 2 0 {name=r1236}
C {devices/bus_connect_nolab.sym} 1610 -2930 2 0 {name=r1237}
C {devices/bus_connect_nolab.sym} 1610 -2950 2 0 {name=r1238}
C {devices/lab_pin.sym} 1600 -2610 3 0 {name=l783 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2030 -2650 2 1 {name=r1239}
C {devices/bus_connect_nolab.sym} 2030 -2670 2 1 {name=r1240}
C {devices/bus_connect_nolab.sym} 2030 -2690 2 1 {name=r1241}
C {devices/bus_connect_nolab.sym} 2030 -2710 2 1 {name=r1242}
C {devices/bus_connect_nolab.sym} 2030 -2730 2 1 {name=r1243}
C {devices/bus_connect_nolab.sym} 2030 -2750 2 1 {name=r1244}
C {devices/bus_connect_nolab.sym} 2030 -2770 2 1 {name=r1245}
C {devices/bus_connect_nolab.sym} 2030 -2790 2 1 {name=r1246}
C {devices/bus_connect_nolab.sym} 2030 -2810 2 1 {name=r1247}
C {devices/bus_connect_nolab.sym} 2030 -2830 2 1 {name=r1248}
C {devices/bus_connect_nolab.sym} 2030 -2850 2 1 {name=r1249}
C {devices/bus_connect_nolab.sym} 2030 -2870 2 1 {name=r1250}
C {devices/bus_connect_nolab.sym} 2030 -2890 2 1 {name=r1251}
C {devices/bus_connect_nolab.sym} 2030 -2910 2 1 {name=r1252}
C {devices/bus_connect_nolab.sym} 2030 -2930 2 1 {name=r1253}
C {devices/bus_connect_nolab.sym} 2030 -2950 2 1 {name=r1254}
C {devices/lab_pin.sym} 2040 -2610 1 1 {name=l784 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 1650 -2670 0 0 {name=l785 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 1650 -2690 0 0 {name=l786 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 1650 -2710 0 0 {name=l787 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 1650 -2730 0 0 {name=l788 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 1650 -2750 0 0 {name=l789 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 1650 -2770 0 0 {name=l790 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 1650 -2790 0 0 {name=l791 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 1650 -2810 0 0 {name=l792 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 1650 -2830 0 0 {name=l793 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 1650 -2870 0 0 {name=l794 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 1650 -2850 0 0 {name=l795 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 1650 -2890 0 0 {name=l796 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 1650 -2910 0 0 {name=l797 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 1650 -2930 0 0 {name=l798 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 1650 -2950 0 0 {name=l799 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 1650 -2650 0 0 {name=l800 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 1990 -2670 0 1 {name=l801 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 1990 -2690 0 1 {name=l802 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 1990 -2710 0 1 {name=l803 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 1990 -2730 0 1 {name=l804 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 1990 -2750 0 1 {name=l805 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 1990 -2770 0 1 {name=l806 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 1990 -2790 0 1 {name=l807 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 1990 -2810 0 1 {name=l808 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 1990 -2830 0 1 {name=l809 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 1990 -2870 0 1 {name=l810 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 1990 -2850 0 1 {name=l811 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 1990 -2890 0 1 {name=l812 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 1990 -2910 0 1 {name=l813 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 1990 -2930 0 1 {name=l814 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 1990 -2950 0 1 {name=l815 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 1990 -2650 0 1 {name=l816 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2190 -3340 2 0 {name=r1255}
C {devices/bus_connect_nolab.sym} 2190 -3360 2 0 {name=r1256}
C {devices/bus_connect_nolab.sym} 2190 -3380 2 0 {name=r1257}
C {devices/bus_connect_nolab.sym} 2190 -3400 2 0 {name=r1258}
C {devices/bus_connect_nolab.sym} 2190 -3420 2 0 {name=r1259}
C {devices/bus_connect_nolab.sym} 2190 -3440 2 0 {name=r1260}
C {devices/bus_connect_nolab.sym} 2190 -3460 2 0 {name=r1261}
C {devices/bus_connect_nolab.sym} 2190 -3480 2 0 {name=r1262}
C {devices/bus_connect_nolab.sym} 2190 -3500 2 0 {name=r1263}
C {devices/bus_connect_nolab.sym} 2190 -3520 2 0 {name=r1264}
C {devices/bus_connect_nolab.sym} 2190 -3560 2 0 {name=r1265}
C {devices/bus_connect_nolab.sym} 2190 -3540 2 0 {name=r1266}
C {devices/bus_connect_nolab.sym} 2190 -3600 2 0 {name=r1267}
C {devices/bus_connect_nolab.sym} 2190 -3580 2 0 {name=r1268}
C {devices/bus_connect_nolab.sym} 2190 -3640 2 0 {name=r1269}
C {devices/bus_connect_nolab.sym} 2190 -3620 2 0 {name=r1270}
C {devices/lab_wire.sym} 2240 -3340 0 0 {name=l817 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2240 -3360 0 0 {name=l818 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2240 -3380 0 0 {name=l819 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -3380 0 0 {name=l820 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2240 -3400 0 0 {name=l821 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2240 -3420 0 0 {name=l822 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2240 -3440 0 0 {name=l823 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2240 -3460 0 0 {name=l824 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2240 -3480 0 0 {name=l825 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2240 -3500 0 0 {name=l826 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2240 -3520 0 0 {name=l827 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2240 -3560 0 0 {name=l828 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2240 -3540 0 0 {name=l829 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2240 -3580 0 0 {name=l830 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2240 -3600 0 0 {name=l831 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2240 -3620 0 0 {name=l832 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2240 -3640 0 0 {name=l833 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2180 -3290 3 0 {name=l834 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 2810 -3340 2 1 {name=r1271}
C {devices/bus_connect_nolab.sym} 2810 -3360 2 1 {name=r1272}
C {devices/bus_connect_nolab.sym} 2810 -3380 2 1 {name=r1273}
C {devices/bus_connect_nolab.sym} 2810 -3400 2 1 {name=r1274}
C {devices/bus_connect_nolab.sym} 2810 -3420 2 1 {name=r1275}
C {devices/bus_connect_nolab.sym} 2810 -3440 2 1 {name=r1276}
C {devices/bus_connect_nolab.sym} 2810 -3460 2 1 {name=r1277}
C {devices/bus_connect_nolab.sym} 2810 -3480 2 1 {name=r1278}
C {devices/bus_connect_nolab.sym} 2810 -3500 2 1 {name=r1279}
C {devices/bus_connect_nolab.sym} 2810 -3520 2 1 {name=r1280}
C {devices/bus_connect_nolab.sym} 2810 -3540 2 1 {name=r1281}
C {devices/bus_connect_nolab.sym} 2810 -3560 2 1 {name=r1282}
C {devices/bus_connect_nolab.sym} 2810 -3580 2 1 {name=r1283}
C {devices/bus_connect_nolab.sym} 2810 -3600 2 1 {name=r1284}
C {devices/bus_connect_nolab.sym} 2810 -3620 2 1 {name=r1285}
C {devices/bus_connect_nolab.sym} 2810 -3640 2 1 {name=r1286}
C {devices/lab_pin.sym} 2820 -3290 3 0 {name=l835 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 2760 -3640 0 1 {name=l836 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 2760 -3620 0 1 {name=l837 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 2760 -3600 0 1 {name=l838 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 2760 -3580 0 1 {name=l839 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 2760 -3560 0 1 {name=l840 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 2760 -3540 0 1 {name=l841 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 2760 -3520 0 1 {name=l842 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 2760 -3500 0 1 {name=l843 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 2760 -3480 0 1 {name=l844 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 2760 -3460 0 1 {name=l845 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 2760 -3440 0 1 {name=l846 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 2760 -3420 0 1 {name=l847 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 2760 -3400 0 1 {name=l848 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 2760 -3380 0 1 {name=l849 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 2760 -3360 0 1 {name=l850 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 2760 -3340 0 1 {name=l851 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 2340 -2660 2 0 {name=r1287}
C {devices/bus_connect_nolab.sym} 2340 -2680 2 0 {name=r1288}
C {devices/bus_connect_nolab.sym} 2340 -2700 2 0 {name=r1289}
C {devices/bus_connect_nolab.sym} 2340 -2720 2 0 {name=r1290}
C {devices/bus_connect_nolab.sym} 2340 -2740 2 0 {name=r1291}
C {devices/bus_connect_nolab.sym} 2340 -2760 2 0 {name=r1292}
C {devices/bus_connect_nolab.sym} 2340 -2780 2 0 {name=r1293}
C {devices/bus_connect_nolab.sym} 2340 -2800 2 0 {name=r1294}
C {devices/bus_connect_nolab.sym} 2340 -2820 2 0 {name=r1295}
C {devices/bus_connect_nolab.sym} 2340 -2840 2 0 {name=r1296}
C {devices/bus_connect_nolab.sym} 2340 -2860 2 0 {name=r1297}
C {devices/bus_connect_nolab.sym} 2340 -2880 2 0 {name=r1298}
C {devices/bus_connect_nolab.sym} 2340 -2900 2 0 {name=r1299}
C {devices/bus_connect_nolab.sym} 2340 -2920 2 0 {name=r1300}
C {devices/bus_connect_nolab.sym} 2340 -2940 2 0 {name=r1301}
C {devices/bus_connect_nolab.sym} 2340 -2960 2 0 {name=r1302}
C {devices/lab_pin.sym} 2330 -2620 3 0 {name=l852 sig_type=std_logic lab=cA[0..15]}
C {devices/bus_connect_nolab.sym} 2760 -2660 2 1 {name=r1303}
C {devices/bus_connect_nolab.sym} 2760 -2680 2 1 {name=r1304}
C {devices/bus_connect_nolab.sym} 2760 -2700 2 1 {name=r1305}
C {devices/bus_connect_nolab.sym} 2760 -2720 2 1 {name=r1306}
C {devices/bus_connect_nolab.sym} 2760 -2740 2 1 {name=r1307}
C {devices/bus_connect_nolab.sym} 2760 -2760 2 1 {name=r1308}
C {devices/bus_connect_nolab.sym} 2760 -2780 2 1 {name=r1309}
C {devices/bus_connect_nolab.sym} 2760 -2800 2 1 {name=r1310}
C {devices/bus_connect_nolab.sym} 2760 -2820 2 1 {name=r1311}
C {devices/bus_connect_nolab.sym} 2760 -2840 2 1 {name=r1312}
C {devices/bus_connect_nolab.sym} 2760 -2860 2 1 {name=r1313}
C {devices/bus_connect_nolab.sym} 2760 -2880 2 1 {name=r1314}
C {devices/bus_connect_nolab.sym} 2760 -2900 2 1 {name=r1315}
C {devices/bus_connect_nolab.sym} 2760 -2920 2 1 {name=r1316}
C {devices/bus_connect_nolab.sym} 2760 -2940 2 1 {name=r1317}
C {devices/bus_connect_nolab.sym} 2760 -2960 2 1 {name=r1318}
C {devices/lab_pin.sym} 2770 -2620 1 1 {name=l853 sig_type=std_logic lab=cB[0..15]}
C {devices/lab_wire.sym} 2380 -2680 0 0 {name=l854 sig_type=std_logic lab=cA1}
C {devices/lab_wire.sym} 2380 -2700 0 0 {name=l855 sig_type=std_logic lab=cA2}
C {devices/lab_wire.sym} 2380 -2720 0 0 {name=l856 sig_type=std_logic lab=cA3}
C {devices/lab_wire.sym} 2380 -2740 0 0 {name=l857 sig_type=std_logic lab=cA4}
C {devices/lab_wire.sym} 2380 -2760 0 0 {name=l858 sig_type=std_logic lab=cA5}
C {devices/lab_wire.sym} 2380 -2780 0 0 {name=l859 sig_type=std_logic lab=cA6}
C {devices/lab_wire.sym} 2380 -2800 0 0 {name=l860 sig_type=std_logic lab=cA7}
C {devices/lab_wire.sym} 2380 -2820 0 0 {name=l861 sig_type=std_logic lab=cA8}
C {devices/lab_wire.sym} 2380 -2840 0 0 {name=l862 sig_type=std_logic lab=cA9}
C {devices/lab_wire.sym} 2380 -2880 0 0 {name=l863 sig_type=std_logic lab=cA11}
C {devices/lab_wire.sym} 2380 -2860 0 0 {name=l864 sig_type=std_logic lab=cA10}
C {devices/lab_wire.sym} 2380 -2900 0 0 {name=l865 sig_type=std_logic lab=cA12}
C {devices/lab_wire.sym} 2380 -2920 0 0 {name=l866 sig_type=std_logic lab=cA13}
C {devices/lab_wire.sym} 2380 -2940 0 0 {name=l867 sig_type=std_logic lab=cA14}
C {devices/lab_wire.sym} 2380 -2960 0 0 {name=l868 sig_type=std_logic lab=cA15}
C {devices/lab_wire.sym} 2380 -2660 0 0 {name=l869 sig_type=std_logic lab=cA0}
C {devices/lab_wire.sym} 2720 -2680 0 1 {name=l870 sig_type=std_logic lab=cB1}
C {devices/lab_wire.sym} 2720 -2700 0 1 {name=l871 sig_type=std_logic lab=cB2}
C {devices/lab_wire.sym} 2720 -2720 0 1 {name=l872 sig_type=std_logic lab=cB3}
C {devices/lab_wire.sym} 2720 -2740 0 1 {name=l873 sig_type=std_logic lab=cB4}
C {devices/lab_wire.sym} 2720 -2760 0 1 {name=l874 sig_type=std_logic lab=cB5}
C {devices/lab_wire.sym} 2720 -2780 0 1 {name=l875 sig_type=std_logic lab=cB6}
C {devices/lab_wire.sym} 2720 -2800 0 1 {name=l876 sig_type=std_logic lab=cB7}
C {devices/lab_wire.sym} 2720 -2820 0 1 {name=l877 sig_type=std_logic lab=cB8}
C {devices/lab_wire.sym} 2720 -2840 0 1 {name=l878 sig_type=std_logic lab=cB9}
C {devices/lab_wire.sym} 2720 -2880 0 1 {name=l879 sig_type=std_logic lab=cB11}
C {devices/lab_wire.sym} 2720 -2860 0 1 {name=l880 sig_type=std_logic lab=cB10}
C {devices/lab_wire.sym} 2720 -2900 0 1 {name=l881 sig_type=std_logic lab=cB12}
C {devices/lab_wire.sym} 2720 -2920 0 1 {name=l882 sig_type=std_logic lab=cB13}
C {devices/lab_wire.sym} 2720 -2940 0 1 {name=l883 sig_type=std_logic lab=cB14}
C {devices/lab_wire.sym} 2720 -2960 0 1 {name=l884 sig_type=std_logic lab=cB15}
C {devices/lab_wire.sym} 2720 -2660 0 1 {name=l885 sig_type=std_logic lab=cB0}
C {devices/bus_connect_nolab.sym} 2890 -3330 2 0 {name=r1319}
C {devices/bus_connect_nolab.sym} 2890 -3350 2 0 {name=r1320}
C {devices/bus_connect_nolab.sym} 2890 -3370 2 0 {name=r1321}
C {devices/bus_connect_nolab.sym} 2890 -3390 2 0 {name=r1322}
C {devices/bus_connect_nolab.sym} 2890 -3410 2 0 {name=r1323}
C {devices/bus_connect_nolab.sym} 2890 -3430 2 0 {name=r1324}
C {devices/bus_connect_nolab.sym} 2890 -3450 2 0 {name=r1325}
C {devices/bus_connect_nolab.sym} 2890 -3470 2 0 {name=r1326}
C {devices/bus_connect_nolab.sym} 2890 -3490 2 0 {name=r1327}
C {devices/bus_connect_nolab.sym} 2890 -3510 2 0 {name=r1328}
C {devices/bus_connect_nolab.sym} 2890 -3550 2 0 {name=r1329}
C {devices/bus_connect_nolab.sym} 2890 -3530 2 0 {name=r1330}
C {devices/bus_connect_nolab.sym} 2890 -3590 2 0 {name=r1331}
C {devices/bus_connect_nolab.sym} 2890 -3570 2 0 {name=r1332}
C {devices/bus_connect_nolab.sym} 2890 -3630 2 0 {name=r1333}
C {devices/bus_connect_nolab.sym} 2890 -3610 2 0 {name=r1334}
C {devices/lab_wire.sym} 2940 -3330 0 0 {name=l886 sig_type=std_logic lab=rA0}
C {devices/lab_wire.sym} 2940 -3350 0 0 {name=l887 sig_type=std_logic lab=rA1}
C {devices/lab_wire.sym} 2940 -3370 0 0 {name=l888 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -3370 0 0 {name=l889 sig_type=std_logic lab=rA2}
C {devices/lab_wire.sym} 2940 -3390 0 0 {name=l890 sig_type=std_logic lab=rA3}
C {devices/lab_wire.sym} 2940 -3410 0 0 {name=l891 sig_type=std_logic lab=rA4}
C {devices/lab_wire.sym} 2940 -3430 0 0 {name=l892 sig_type=std_logic lab=rA5}
C {devices/lab_wire.sym} 2940 -3450 0 0 {name=l893 sig_type=std_logic lab=rA6}
C {devices/lab_wire.sym} 2940 -3470 0 0 {name=l894 sig_type=std_logic lab=rA7}
C {devices/lab_wire.sym} 2940 -3490 0 0 {name=l895 sig_type=std_logic lab=rA8}
C {devices/lab_wire.sym} 2940 -3510 0 0 {name=l896 sig_type=std_logic lab=rA9}
C {devices/lab_wire.sym} 2940 -3550 0 0 {name=l897 sig_type=std_logic lab=rA11}
C {devices/lab_wire.sym} 2940 -3530 0 0 {name=l898 sig_type=std_logic lab=rA10}
C {devices/lab_wire.sym} 2940 -3570 0 0 {name=l899 sig_type=std_logic lab=rA12}
C {devices/lab_wire.sym} 2940 -3590 0 0 {name=l900 sig_type=std_logic lab=rA13}
C {devices/lab_wire.sym} 2940 -3610 0 0 {name=l901 sig_type=std_logic lab=rA14}
C {devices/lab_wire.sym} 2940 -3630 0 0 {name=l902 sig_type=std_logic lab=rA15}
C {devices/lab_pin.sym} 2880 -3280 3 0 {name=l903 sig_type=std_logic lab=rA[0..15]}
C {devices/bus_connect_nolab.sym} 3510 -3330 2 1 {name=r1335}
C {devices/bus_connect_nolab.sym} 3510 -3350 2 1 {name=r1336}
C {devices/bus_connect_nolab.sym} 3510 -3370 2 1 {name=r1337}
C {devices/bus_connect_nolab.sym} 3510 -3390 2 1 {name=r1338}
C {devices/bus_connect_nolab.sym} 3510 -3410 2 1 {name=r1339}
C {devices/bus_connect_nolab.sym} 3510 -3430 2 1 {name=r1340}
C {devices/bus_connect_nolab.sym} 3510 -3450 2 1 {name=r1341}
C {devices/bus_connect_nolab.sym} 3510 -3470 2 1 {name=r1342}
C {devices/bus_connect_nolab.sym} 3510 -3490 2 1 {name=r1343}
C {devices/bus_connect_nolab.sym} 3510 -3510 2 1 {name=r1344}
C {devices/bus_connect_nolab.sym} 3510 -3530 2 1 {name=r1345}
C {devices/bus_connect_nolab.sym} 3510 -3550 2 1 {name=r1346}
C {devices/bus_connect_nolab.sym} 3510 -3570 2 1 {name=r1347}
C {devices/bus_connect_nolab.sym} 3510 -3590 2 1 {name=r1348}
C {devices/bus_connect_nolab.sym} 3510 -3610 2 1 {name=r1349}
C {devices/bus_connect_nolab.sym} 3510 -3630 2 1 {name=r1350}
C {devices/lab_pin.sym} 3520 -3280 3 0 {name=l904 sig_type=std_logic lab=rB[0..15]}
C {devices/lab_wire.sym} 3460 -3630 0 1 {name=l905 sig_type=std_logic lab=rB15}
C {devices/lab_wire.sym} 3460 -3610 0 1 {name=l906 sig_type=std_logic lab=rB14}
C {devices/lab_wire.sym} 3460 -3590 0 1 {name=l907 sig_type=std_logic lab=rB13}
C {devices/lab_wire.sym} 3460 -3570 0 1 {name=l908 sig_type=std_logic lab=rB12}
C {devices/lab_wire.sym} 3460 -3550 0 1 {name=l909 sig_type=std_logic lab=rB11}
C {devices/lab_wire.sym} 3460 -3530 0 1 {name=l910 sig_type=std_logic lab=rB10}
C {devices/lab_wire.sym} 3460 -3510 0 1 {name=l911 sig_type=std_logic lab=rB9}
C {devices/lab_wire.sym} 3460 -3490 0 1 {name=l912 sig_type=std_logic lab=rB8}
C {devices/lab_wire.sym} 3460 -3470 0 1 {name=l913 sig_type=std_logic lab=rB7}
C {devices/lab_wire.sym} 3460 -3450 0 1 {name=l914 sig_type=std_logic lab=rB6}
C {devices/lab_wire.sym} 3460 -3430 0 1 {name=l915 sig_type=std_logic lab=rB5}
C {devices/lab_wire.sym} 3460 -3410 0 1 {name=l916 sig_type=std_logic lab=rB4}
C {devices/lab_wire.sym} 3460 -3390 0 1 {name=l917 sig_type=std_logic lab=rB3}
C {devices/lab_wire.sym} 3460 -3370 0 1 {name=l918 sig_type=std_logic lab=rB2}
C {devices/lab_wire.sym} 3460 -3350 0 1 {name=l919 sig_type=std_logic lab=rB1}
C {devices/lab_wire.sym} 3460 -3330 0 1 {name=l920 sig_type=std_logic lab=rB0}
C {devices/bus_connect_nolab.sym} 3040 -2650 2 0 {name=r1351}
